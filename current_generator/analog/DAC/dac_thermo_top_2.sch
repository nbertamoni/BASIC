v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 100 -1900 120 -1900 {lab=VBIAS}
N 100 -1880 120 -1880 {lab=enb}
N 420 -1880 440 -1880 {lab=DATA3}
N 270 -1800 270 -1780 {lab=AVSS}
N 200 -1800 200 -1780 {lab=ISUM}
N 270 -1980 270 -1960 {lab=AVDD}
N 610 -1900 630 -1900 {lab=VBIAS}
N 610 -1880 630 -1880 {lab=enb}
N 930 -1880 950 -1880 {lab=DATA4}
N 780 -1800 780 -1780 {lab=AVSS}
N 710 -1800 710 -1780 {lab=ISUM}
N 780 -1980 780 -1960 {lab=AVDD}
N 1160 -1900 1180 -1900 {lab=VBIAS}
N 1160 -1880 1180 -1880 {lab=enb}
N 1480 -1880 1500 -1880 {lab=DATA5}
N 1330 -1800 1330 -1780 {lab=AVSS}
N 1260 -1800 1260 -1780 {lab=ISUM}
N 1330 -1980 1330 -1960 {lab=AVDD}
N 1650 -1900 1670 -1900 {lab=VBIAS}
N 1650 -1880 1670 -1880 {lab=enb}
N 1970 -1880 1990 -1880 {lab=DATA6}
N 1820 -1800 1820 -1780 {lab=AVSS}
N 1750 -1800 1750 -1780 {lab=ISUM}
N 1820 -1980 1820 -1960 {lab=AVDD}
N 2160 -1900 2180 -1900 {lab=VBIAS}
N 2160 -1880 2180 -1880 {lab=enb}
N 2480 -1880 2500 -1880 {lab=DATA7}
N 2330 -1800 2330 -1780 {lab=AVSS}
N 2260 -1800 2260 -1780 {lab=ISUM}
N 2330 -1980 2330 -1960 {lab=AVDD}
N 2730 -1930 2750 -1930 {lab=VBIAS}
N 2730 -1910 2750 -1910 {lab=enb}
N 3050 -1910 3070 -1910 {lab=DATA8}
N 2900 -1830 2900 -1810 {lab=AVSS}
N 2830 -1830 2830 -1810 {lab=ISUM}
N 2900 -2010 2900 -1990 {lab=AVDD}
N 3290 -1930 3310 -1930 {lab=VBIAS}
N 3290 -1910 3310 -1910 {lab=enb}
N 3610 -1910 3630 -1910 {lab=DATA9}
N 3460 -1830 3460 -1810 {lab=AVSS}
N 3390 -1830 3390 -1810 {lab=ISUM}
N 3460 -2010 3460 -1990 {lab=AVDD}
N 3840 -1930 3860 -1930 {lab=VBIAS}
N 3840 -1910 3860 -1910 {lab=enb}
N 4160 -1910 4180 -1910 {lab=DATA10}
N 4010 -1830 4010 -1810 {lab=AVSS}
N 3940 -1830 3940 -1810 {lab=ISUM}
N 4010 -2010 4010 -1990 {lab=AVDD}
N 90 -1570 110 -1570 {lab=VBIAS}
N 90 -1550 110 -1550 {lab=enb}
N 410 -1550 430 -1550 {lab=DATA11}
N 260 -1470 260 -1450 {lab=AVSS}
N 190 -1470 190 -1450 {lab=ISUM}
N 260 -1650 260 -1630 {lab=AVDD}
N 610 -1580 630 -1580 {lab=VBIAS}
N 610 -1560 630 -1560 {lab=enb}
N 930 -1560 950 -1560 {lab=DATA12}
N 780 -1480 780 -1460 {lab=AVSS}
N 710 -1480 710 -1460 {lab=ISUM}
N 780 -1660 780 -1640 {lab=AVDD}
N 1160 -1570 1180 -1570 {lab=VBIAS}
N 1160 -1550 1180 -1550 {lab=enb}
N 1480 -1550 1500 -1550 {lab=DATA13}
N 1330 -1470 1330 -1450 {lab=AVSS}
N 1260 -1470 1260 -1450 {lab=ISUM}
N 1330 -1650 1330 -1630 {lab=AVDD}
N 1650 -1570 1670 -1570 {lab=VBIAS}
N 1650 -1550 1670 -1550 {lab=enb}
N 1970 -1550 1990 -1550 {lab=DATA14}
N 1820 -1470 1820 -1450 {lab=AVSS}
N 1750 -1470 1750 -1450 {lab=ISUM}
N 1820 -1650 1820 -1630 {lab=AVDD}
N 2160 -1570 2180 -1570 {lab=VBIAS}
N 2160 -1550 2180 -1550 {lab=enb}
N 2480 -1550 2500 -1550 {lab=DATA15}
N 2330 -1470 2330 -1450 {lab=AVSS}
N 2260 -1470 2260 -1450 {lab=ISUM}
N 2330 -1650 2330 -1630 {lab=AVDD}
N 2730 -1560 2750 -1560 {lab=VBIAS}
N 2730 -1540 2750 -1540 {lab=enb}
N 3050 -1540 3070 -1540 {lab=DATA16}
N 2900 -1460 2900 -1440 {lab=AVSS}
N 2830 -1460 2830 -1440 {lab=ISUM}
N 2900 -1640 2900 -1620 {lab=AVDD}
N 3290 -1560 3310 -1560 {lab=VBIAS}
N 3290 -1540 3310 -1540 {lab=enb}
N 3610 -1540 3630 -1540 {lab=DATA17}
N 3460 -1460 3460 -1440 {lab=AVSS}
N 3390 -1460 3390 -1440 {lab=ISUM}
N 3460 -1640 3460 -1620 {lab=AVDD}
N 340 -2410 390 -2410 {lab=AVDD}
N 340 -2380 390 -2380 {lab=AVSS}
N 340 -2350 390 -2350 {lab=VBIAS}
N 530 -2410 580 -2410 {lab=DATA3}
N 340 -2320 390 -2320 {lab=en_bb}
N 340 -2290 390 -2290 {lab=ISUM}
N 530 -2380 580 -2380 {lab=DATA4}
N 530 -2350 580 -2350 {lab=DATA5}
N 530 -2320 580 -2320 {lab=DATA6}
N 530 -2290 580 -2290 {lab=DATA7}
N 690 -2410 740 -2410 {lab=DATA8}
N 690 -2380 740 -2380 {lab=DATA9}
N 690 -2350 740 -2350 {lab=DATA10}
N 690 -2320 740 -2320 {lab=DATA11}
N 690 -2290 740 -2290 {lab=DATA12}
N 850 -2410 900 -2410 {lab=DATA13}
N 850 -2380 900 -2380 {lab=DATA14}
N 850 -2350 900 -2350 {lab=DATA15}
N 850 -2320 900 -2320 {lab=DATA16}
N 850 -2290 900 -2290 {lab=DATA17}
C {dac.sym} 270 -1880 0 0 {name=x1[7:0]}
C {lab_wire.sym} 270 -1970 0 0 {name=p16 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -1780 0 1 {name=p13 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -1880 0 1 {name=p14 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -1900 0 0 {name=p28 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -1780 0 0 {name=p35 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -1880 0 0 {name=p42 sig_type=std_logic lab=enb}
C {dac.sym} 780 -1880 0 0 {name=x9[7:0]}
C {lab_wire.sym} 780 -1970 0 0 {name=p49 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 780 -1780 0 1 {name=p50 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 940 -1880 0 1 {name=p51 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 620 -1900 0 0 {name=p52 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 710 -1780 0 0 {name=p53 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 610 -1880 0 0 {name=p54 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -1880 0 0 {name=x17[7:0]}
C {lab_wire.sym} 1330 -1970 0 0 {name=p97 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -1780 0 1 {name=p98 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -1880 0 1 {name=p99 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -1900 0 0 {name=p100 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -1780 0 0 {name=p101 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -1880 0 0 {name=p102 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -1880 0 0 {name=x25[7:0]}
C {lab_wire.sym} 1820 -1970 0 0 {name=p145 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -1780 0 1 {name=p146 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -1880 0 1 {name=p147 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -1900 0 0 {name=p148 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -1780 0 0 {name=p149 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -1880 0 0 {name=p150 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -1880 0 0 {name=x33[7:0]}
C {lab_wire.sym} 2330 -1970 0 0 {name=p193 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -1780 0 1 {name=p194 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -1880 0 1 {name=p195 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -1900 0 0 {name=p196 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -1780 0 0 {name=p197 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -1880 0 0 {name=p198 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -1910 0 0 {name=x41[7:0]}
C {lab_wire.sym} 2900 -2000 0 0 {name=p241 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -1810 0 1 {name=p242 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -1910 0 1 {name=p243 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -1930 0 0 {name=p244 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -1810 0 0 {name=p245 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -1910 0 0 {name=p246 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -1910 0 0 {name=x49[7:0]}
C {lab_wire.sym} 3460 -2000 0 0 {name=p289 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -1810 0 1 {name=p290 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -1910 0 1 {name=p291 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -1930 0 0 {name=p292 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -1810 0 0 {name=p293 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -1910 0 0 {name=p294 sig_type=std_logic lab=enb}
C {dac.sym} 4010 -1910 0 0 {name=x57[7:0]}
C {lab_wire.sym} 4010 -2000 0 0 {name=p337 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4010 -1810 0 1 {name=p338 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4170 -1910 0 1 {name=p339 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3850 -1930 0 0 {name=p340 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3940 -1810 0 0 {name=p341 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3840 -1910 0 0 {name=p342 sig_type=std_logic lab=enb}
C {dac.sym} 260 -1550 0 0 {name=x65[7:0]}
C {lab_wire.sym} 260 -1640 0 0 {name=p385 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 260 -1450 0 1 {name=p386 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 420 -1550 0 1 {name=p387 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 100 -1570 0 0 {name=p388 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 190 -1450 0 0 {name=p389 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 90 -1550 0 0 {name=p390 sig_type=std_logic lab=enb}
C {dac.sym} 780 -1560 0 0 {name=x73[7:0]}
C {lab_wire.sym} 780 -1650 0 0 {name=p433 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 780 -1460 0 1 {name=p434 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 940 -1560 0 1 {name=p435 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 620 -1580 0 0 {name=p436 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 710 -1460 0 0 {name=p437 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 610 -1560 0 0 {name=p438 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -1550 0 0 {name=x81[7:0]}
C {lab_wire.sym} 1330 -1640 0 0 {name=p481 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -1450 0 1 {name=p482 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -1550 0 1 {name=p483 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 1170 -1570 0 0 {name=p484 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -1450 0 0 {name=p485 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -1550 0 0 {name=p486 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -1550 0 0 {name=x89[7:0]}
C {lab_wire.sym} 1820 -1640 0 0 {name=p529 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -1450 0 1 {name=p530 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -1550 0 1 {name=p531 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 1660 -1570 0 0 {name=p532 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -1450 0 0 {name=p533 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -1550 0 0 {name=p534 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -1550 0 0 {name=x97[7:0]}
C {lab_wire.sym} 2330 -1640 0 0 {name=p577 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -1450 0 1 {name=p578 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -1550 0 1 {name=p579 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 2170 -1570 0 0 {name=p580 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -1450 0 0 {name=p581 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -1550 0 0 {name=p582 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -1540 0 0 {name=x105[7:0]}
C {lab_wire.sym} 2900 -1630 0 0 {name=p625 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -1440 0 1 {name=p626 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -1540 0 1 {name=p627 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 2740 -1560 0 0 {name=p628 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -1440 0 0 {name=p629 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -1540 0 0 {name=p630 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -1540 0 0 {name=x113[7:0]}
C {lab_wire.sym} 3460 -1630 0 0 {name=p673 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -1440 0 1 {name=p674 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -1540 0 1 {name=p675 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 3300 -1560 0 0 {name=p676 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -1440 0 0 {name=p677 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -1540 0 0 {name=p678 sig_type=std_logic lab=enb}
C {iopin.sym} 340 -2410 2 0 {name=p721 lab=AVDD}
C {iopin.sym} 340 -2380 2 0 {name=p722 lab=AVSS}
C {iopin.sym} 340 -2350 2 0 {name=p723 lab=VBIAS}
C {iopin.sym} 340 -2320 2 0 {name=p724 lab=en_bb}
C {iopin.sym} 530 -2380 2 0 {name=p725 lab=DATA4}
C {iopin.sym} 340 -2290 2 0 {name=p726 lab=ISUM}
C {iopin.sym} 530 -2410 2 0 {name=p727 lab=DATA3}
C {iopin.sym} 530 -2350 2 0 {name=p728 lab=DATA5}
C {iopin.sym} 530 -2290 2 0 {name=p729 lab=DATA7}
C {iopin.sym} 530 -2320 2 0 {name=p730 lab=DATA6}
C {iopin.sym} 690 -2410 2 0 {name=p731 lab=DATA8}
C {iopin.sym} 690 -2380 2 0 {name=p732 lab=DATA9}
C {iopin.sym} 690 -2350 2 0 {name=p733 lab=DATA10}
C {iopin.sym} 690 -2290 2 0 {name=p734 lab=DATA12}
C {iopin.sym} 690 -2320 2 0 {name=p735 lab=DATA11}
C {iopin.sym} 850 -2410 2 0 {name=p736 lab=DATA13}
C {iopin.sym} 850 -2380 2 0 {name=p737 lab=DATA14}
C {iopin.sym} 850 -2350 2 0 {name=p738 lab=DATA15}
C {iopin.sym} 850 -2320 2 0 {name=p739 lab=DATA16}
C {iopin.sym} 850 -2290 2 0 {name=p740 lab=DATA17}
