v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 100 -1900 120 -1900 {lab=VBIAS}
N 100 -1880 120 -1880 {lab=enb}
N 420 -1880 440 -1880 {lab=DATA3}
N 270 -1800 270 -1780 {lab=AVSS}
N 200 -1800 200 -1780 {lab=ISUM}
N 270 -1980 270 -1960 {lab=AVDD}
N 100 -1670 120 -1670 {lab=VBIAS}
N 100 -1650 120 -1650 {lab=enb}
N 420 -1650 440 -1650 {lab=DATA3}
N 270 -1570 270 -1550 {lab=AVSS}
N 200 -1570 200 -1550 {lab=ISUM}
N 270 -1750 270 -1730 {lab=AVDD}
N 100 -1440 120 -1440 {lab=VBIAS}
N 100 -1420 120 -1420 {lab=enb}
N 420 -1420 440 -1420 {lab=DATA3}
N 270 -1340 270 -1320 {lab=AVSS}
N 200 -1340 200 -1320 {lab=ISUM}
N 270 -1520 270 -1500 {lab=AVDD}
N 100 -1200 120 -1200 {lab=VBIAS}
N 100 -1180 120 -1180 {lab=enb}
N 420 -1180 440 -1180 {lab=DATA3}
N 270 -1100 270 -1080 {lab=AVSS}
N 200 -1100 200 -1080 {lab=ISUM}
N 270 -1280 270 -1260 {lab=AVDD}
N 100 -940 120 -940 {lab=VBIAS}
N 100 -920 120 -920 {lab=enb}
N 420 -920 440 -920 {lab=DATA3}
N 270 -840 270 -820 {lab=AVSS}
N 200 -840 200 -820 {lab=ISUM}
N 270 -1020 270 -1000 {lab=AVDD}
N 100 -710 120 -710 {lab=VBIAS}
N 100 -690 120 -690 {lab=enb}
N 420 -690 440 -690 {lab=DATA3}
N 270 -610 270 -590 {lab=AVSS}
N 200 -610 200 -590 {lab=ISUM}
N 270 -790 270 -770 {lab=AVDD}
N 100 -480 120 -480 {lab=VBIAS}
N 100 -460 120 -460 {lab=enb}
N 420 -460 440 -460 {lab=DATA3}
N 270 -380 270 -360 {lab=AVSS}
N 200 -380 200 -360 {lab=ISUM}
N 270 -560 270 -540 {lab=AVDD}
N 100 -240 120 -240 {lab=VBIAS}
N 100 -220 120 -220 {lab=enb}
N 420 -220 440 -220 {lab=DATA3}
N 270 -140 270 -120 {lab=AVSS}
N 200 -140 200 -120 {lab=ISUM}
N 270 -320 270 -300 {lab=AVDD}
N 610 -1900 630 -1900 {lab=VBIAS}
N 610 -1880 630 -1880 {lab=enb}
N 930 -1880 950 -1880 {lab=DATA4}
N 780 -1800 780 -1780 {lab=AVSS}
N 710 -1800 710 -1780 {lab=ISUM}
N 780 -1980 780 -1960 {lab=AVDD}
N 610 -1670 630 -1670 {lab=VBIAS}
N 610 -1650 630 -1650 {lab=enb}
N 930 -1650 950 -1650 {lab=DATA4}
N 780 -1570 780 -1550 {lab=AVSS}
N 710 -1570 710 -1550 {lab=ISUM}
N 780 -1750 780 -1730 {lab=AVDD}
N 620 -1440 640 -1440 {lab=VBIAS}
N 620 -1420 640 -1420 {lab=enb}
N 940 -1420 960 -1420 {lab=DATA4}
N 790 -1340 790 -1320 {lab=AVSS}
N 720 -1340 720 -1320 {lab=ISUM}
N 790 -1520 790 -1500 {lab=AVDD}
N 620 -1210 640 -1210 {lab=VBIAS}
N 620 -1190 640 -1190 {lab=enb}
N 940 -1190 960 -1190 {lab=DATA4}
N 790 -1110 790 -1090 {lab=AVSS}
N 720 -1110 720 -1090 {lab=ISUM}
N 790 -1290 790 -1270 {lab=AVDD}
N 620 -930 640 -930 {lab=VBIAS}
N 620 -910 640 -910 {lab=enb}
N 940 -910 960 -910 {lab=DATA4}
N 790 -830 790 -810 {lab=AVSS}
N 720 -830 720 -810 {lab=ISUM}
N 790 -1010 790 -990 {lab=AVDD}
N 620 -700 640 -700 {lab=VBIAS}
N 620 -680 640 -680 {lab=enb}
N 940 -680 960 -680 {lab=DATA4}
N 790 -600 790 -580 {lab=AVSS}
N 720 -600 720 -580 {lab=ISUM}
N 790 -780 790 -760 {lab=AVDD}
N 630 -470 650 -470 {lab=VBIAS}
N 630 -450 650 -450 {lab=enb}
N 950 -450 970 -450 {lab=DATA4}
N 800 -370 800 -350 {lab=AVSS}
N 730 -370 730 -350 {lab=ISUM}
N 800 -550 800 -530 {lab=AVDD}
N 630 -240 650 -240 {lab=VBIAS}
N 630 -220 650 -220 {lab=enb}
N 950 -220 970 -220 {lab=DATA4}
N 800 -140 800 -120 {lab=AVSS}
N 730 -140 730 -120 {lab=ISUM}
N 800 -320 800 -300 {lab=AVDD}
N 1160 -1900 1180 -1900 {lab=VBIAS}
N 1160 -1880 1180 -1880 {lab=enb}
N 1480 -1880 1500 -1880 {lab=DATA4}
N 1330 -1800 1330 -1780 {lab=AVSS}
N 1260 -1800 1260 -1780 {lab=ISUM}
N 1330 -1980 1330 -1960 {lab=AVDD}
N 1160 -1660 1180 -1660 {lab=VBIAS}
N 1160 -1640 1180 -1640 {lab=enb}
N 1480 -1640 1500 -1640 {lab=DATA4}
N 1330 -1560 1330 -1540 {lab=AVSS}
N 1260 -1560 1260 -1540 {lab=ISUM}
N 1330 -1740 1330 -1720 {lab=AVDD}
N 1160 -1410 1180 -1410 {lab=VBIAS}
N 1160 -1390 1180 -1390 {lab=enb}
N 1480 -1390 1500 -1390 {lab=DATA4}
N 1330 -1310 1330 -1290 {lab=AVSS}
N 1260 -1310 1260 -1290 {lab=ISUM}
N 1330 -1490 1330 -1470 {lab=AVDD}
N 1160 -1170 1180 -1170 {lab=VBIAS}
N 1160 -1150 1180 -1150 {lab=enb}
N 1480 -1150 1500 -1150 {lab=DATA4}
N 1330 -1070 1330 -1050 {lab=AVSS}
N 1260 -1070 1260 -1050 {lab=ISUM}
N 1330 -1250 1330 -1230 {lab=AVDD}
N 1160 -940 1180 -940 {lab=VBIAS}
N 1160 -920 1180 -920 {lab=enb}
N 1480 -920 1500 -920 {lab=DATA4}
N 1330 -840 1330 -820 {lab=AVSS}
N 1260 -840 1260 -820 {lab=ISUM}
N 1330 -1020 1330 -1000 {lab=AVDD}
N 1160 -700 1180 -700 {lab=VBIAS}
N 1160 -680 1180 -680 {lab=enb}
N 1480 -680 1500 -680 {lab=DATA4}
N 1330 -600 1330 -580 {lab=AVSS}
N 1260 -600 1260 -580 {lab=ISUM}
N 1330 -780 1330 -760 {lab=AVDD}
N 1160 -450 1180 -450 {lab=VBIAS}
N 1160 -430 1180 -430 {lab=enb}
N 1480 -430 1500 -430 {lab=DATA4}
N 1330 -350 1330 -330 {lab=AVSS}
N 1260 -350 1260 -330 {lab=ISUM}
N 1330 -530 1330 -510 {lab=AVDD}
N 1160 -210 1180 -210 {lab=VBIAS}
N 1160 -190 1180 -190 {lab=enb}
N 1480 -190 1500 -190 {lab=DATA4}
N 1330 -110 1330 -90 {lab=AVSS}
N 1260 -110 1260 -90 {lab=ISUM}
N 1330 -290 1330 -270 {lab=AVDD}
N 1650 -1900 1670 -1900 {lab=VBIAS}
N 1650 -1880 1670 -1880 {lab=enb}
N 1970 -1880 1990 -1880 {lab=DATA4}
N 1820 -1800 1820 -1780 {lab=AVSS}
N 1750 -1800 1750 -1780 {lab=ISUM}
N 1820 -1980 1820 -1960 {lab=AVDD}
N 1650 -1670 1670 -1670 {lab=VBIAS}
N 1650 -1650 1670 -1650 {lab=enb}
N 1970 -1650 1990 -1650 {lab=DATA4}
N 1820 -1570 1820 -1550 {lab=AVSS}
N 1750 -1570 1750 -1550 {lab=ISUM}
N 1820 -1750 1820 -1730 {lab=AVDD}
N 1650 -1420 1670 -1420 {lab=VBIAS}
N 1650 -1400 1670 -1400 {lab=enb}
N 1970 -1400 1990 -1400 {lab=DATA4}
N 1820 -1320 1820 -1300 {lab=AVSS}
N 1750 -1320 1750 -1300 {lab=ISUM}
N 1820 -1500 1820 -1480 {lab=AVDD}
N 1650 -1190 1670 -1190 {lab=VBIAS}
N 1650 -1170 1670 -1170 {lab=enb}
N 1970 -1170 1990 -1170 {lab=DATA4}
N 1820 -1090 1820 -1070 {lab=AVSS}
N 1750 -1090 1750 -1070 {lab=ISUM}
N 1820 -1270 1820 -1250 {lab=AVDD}
N 1650 -940 1670 -940 {lab=VBIAS}
N 1650 -920 1670 -920 {lab=enb}
N 1970 -920 1990 -920 {lab=DATA4}
N 1820 -840 1820 -820 {lab=AVSS}
N 1750 -840 1750 -820 {lab=ISUM}
N 1820 -1020 1820 -1000 {lab=AVDD}
N 1650 -710 1670 -710 {lab=VBIAS}
N 1650 -690 1670 -690 {lab=enb}
N 1970 -690 1990 -690 {lab=DATA4}
N 1820 -610 1820 -590 {lab=AVSS}
N 1750 -610 1750 -590 {lab=ISUM}
N 1820 -790 1820 -770 {lab=AVDD}
N 1650 -460 1670 -460 {lab=VBIAS}
N 1650 -440 1670 -440 {lab=enb}
N 1970 -440 1990 -440 {lab=DATA4}
N 1820 -360 1820 -340 {lab=AVSS}
N 1750 -360 1750 -340 {lab=ISUM}
N 1820 -540 1820 -520 {lab=AVDD}
N 1650 -230 1670 -230 {lab=VBIAS}
N 1650 -210 1670 -210 {lab=enb}
N 1970 -210 1990 -210 {lab=DATA4}
N 1820 -130 1820 -110 {lab=AVSS}
N 1750 -130 1750 -110 {lab=ISUM}
N 1820 -310 1820 -290 {lab=AVDD}
N 2160 -1900 2180 -1900 {lab=VBIAS}
N 2160 -1880 2180 -1880 {lab=enb}
N 2480 -1880 2500 -1880 {lab=DATA4}
N 2330 -1800 2330 -1780 {lab=AVSS}
N 2260 -1800 2260 -1780 {lab=ISUM}
N 2330 -1980 2330 -1960 {lab=AVDD}
N 2160 -1660 2180 -1660 {lab=VBIAS}
N 2160 -1640 2180 -1640 {lab=enb}
N 2480 -1640 2500 -1640 {lab=DATA4}
N 2330 -1560 2330 -1540 {lab=AVSS}
N 2260 -1560 2260 -1540 {lab=ISUM}
N 2330 -1740 2330 -1720 {lab=AVDD}
N 2160 -1410 2180 -1410 {lab=VBIAS}
N 2160 -1390 2180 -1390 {lab=enb}
N 2480 -1390 2500 -1390 {lab=DATA4}
N 2330 -1310 2330 -1290 {lab=AVSS}
N 2260 -1310 2260 -1290 {lab=ISUM}
N 2330 -1490 2330 -1470 {lab=AVDD}
N 2160 -1170 2180 -1170 {lab=VBIAS}
N 2160 -1150 2180 -1150 {lab=enb}
N 2480 -1150 2500 -1150 {lab=DATA4}
N 2330 -1070 2330 -1050 {lab=AVSS}
N 2260 -1070 2260 -1050 {lab=ISUM}
N 2330 -1250 2330 -1230 {lab=AVDD}
N 2160 -940 2180 -940 {lab=VBIAS}
N 2160 -920 2180 -920 {lab=enb}
N 2480 -920 2500 -920 {lab=DATA4}
N 2330 -840 2330 -820 {lab=AVSS}
N 2260 -840 2260 -820 {lab=ISUM}
N 2330 -1020 2330 -1000 {lab=AVDD}
N 2160 -700 2180 -700 {lab=VBIAS}
N 2160 -680 2180 -680 {lab=enb}
N 2480 -680 2500 -680 {lab=DATA4}
N 2330 -600 2330 -580 {lab=AVSS}
N 2260 -600 2260 -580 {lab=ISUM}
N 2330 -780 2330 -760 {lab=AVDD}
N 2160 -450 2180 -450 {lab=VBIAS}
N 2160 -430 2180 -430 {lab=enb}
N 2480 -430 2500 -430 {lab=DATA4}
N 2330 -350 2330 -330 {lab=AVSS}
N 2260 -350 2260 -330 {lab=ISUM}
N 2330 -530 2330 -510 {lab=AVDD}
N 2160 -210 2180 -210 {lab=VBIAS}
N 2160 -190 2180 -190 {lab=enb}
N 2480 -190 2500 -190 {lab=DATA4}
N 2330 -110 2330 -90 {lab=AVSS}
N 2260 -110 2260 -90 {lab=ISUM}
N 2330 -290 2330 -270 {lab=AVDD}
N 2730 -1930 2750 -1930 {lab=VBIAS}
N 2730 -1910 2750 -1910 {lab=enb}
N 3050 -1910 3070 -1910 {lab=DATA4}
N 2900 -1830 2900 -1810 {lab=AVSS}
N 2830 -1830 2830 -1810 {lab=ISUM}
N 2900 -2010 2900 -1990 {lab=AVDD}
N 2730 -1680 2750 -1680 {lab=VBIAS}
N 2730 -1660 2750 -1660 {lab=enb}
N 3050 -1660 3070 -1660 {lab=DATA4}
N 2900 -1580 2900 -1560 {lab=AVSS}
N 2830 -1580 2830 -1560 {lab=ISUM}
N 2900 -1760 2900 -1740 {lab=AVDD}
N 2730 -1440 2750 -1440 {lab=VBIAS}
N 2730 -1420 2750 -1420 {lab=enb}
N 3050 -1420 3070 -1420 {lab=DATA4}
N 2900 -1340 2900 -1320 {lab=AVSS}
N 2830 -1340 2830 -1320 {lab=ISUM}
N 2900 -1520 2900 -1500 {lab=AVDD}
N 2730 -1190 2750 -1190 {lab=VBIAS}
N 2730 -1170 2750 -1170 {lab=enb}
N 3050 -1170 3070 -1170 {lab=DATA4}
N 2900 -1090 2900 -1070 {lab=AVSS}
N 2830 -1090 2830 -1070 {lab=ISUM}
N 2900 -1270 2900 -1250 {lab=AVDD}
N 2730 -940 2750 -940 {lab=VBIAS}
N 2730 -920 2750 -920 {lab=enb}
N 3050 -920 3070 -920 {lab=DATA4}
N 2900 -840 2900 -820 {lab=AVSS}
N 2830 -840 2830 -820 {lab=ISUM}
N 2900 -1020 2900 -1000 {lab=AVDD}
N 2730 -690 2750 -690 {lab=VBIAS}
N 2730 -670 2750 -670 {lab=enb}
N 3050 -670 3070 -670 {lab=DATA4}
N 2900 -590 2900 -570 {lab=AVSS}
N 2830 -590 2830 -570 {lab=ISUM}
N 2900 -770 2900 -750 {lab=AVDD}
N 2730 -450 2750 -450 {lab=VBIAS}
N 2730 -430 2750 -430 {lab=enb}
N 3050 -430 3070 -430 {lab=DATA4}
N 2900 -350 2900 -330 {lab=AVSS}
N 2830 -350 2830 -330 {lab=ISUM}
N 2900 -530 2900 -510 {lab=AVDD}
N 2730 -200 2750 -200 {lab=VBIAS}
N 2730 -180 2750 -180 {lab=enb}
N 3050 -180 3070 -180 {lab=DATA4}
N 2900 -100 2900 -80 {lab=AVSS}
N 2830 -100 2830 -80 {lab=ISUM}
N 2900 -280 2900 -260 {lab=AVDD}
N 3290 -1930 3310 -1930 {lab=VBIAS}
N 3290 -1910 3310 -1910 {lab=enb}
N 3610 -1910 3630 -1910 {lab=DATA4}
N 3460 -1830 3460 -1810 {lab=AVSS}
N 3390 -1830 3390 -1810 {lab=ISUM}
N 3460 -2010 3460 -1990 {lab=AVDD}
N 3290 -1680 3310 -1680 {lab=VBIAS}
N 3290 -1660 3310 -1660 {lab=enb}
N 3610 -1660 3630 -1660 {lab=DATA4}
N 3460 -1580 3460 -1560 {lab=AVSS}
N 3390 -1580 3390 -1560 {lab=ISUM}
N 3460 -1760 3460 -1740 {lab=AVDD}
N 3290 -1430 3310 -1430 {lab=VBIAS}
N 3290 -1410 3310 -1410 {lab=enb}
N 3610 -1410 3630 -1410 {lab=DATA4}
N 3460 -1330 3460 -1310 {lab=AVSS}
N 3390 -1330 3390 -1310 {lab=ISUM}
N 3460 -1510 3460 -1490 {lab=AVDD}
N 3290 -1180 3310 -1180 {lab=VBIAS}
N 3290 -1160 3310 -1160 {lab=enb}
N 3610 -1160 3630 -1160 {lab=DATA4}
N 3460 -1080 3460 -1060 {lab=AVSS}
N 3390 -1080 3390 -1060 {lab=ISUM}
N 3460 -1260 3460 -1240 {lab=AVDD}
N 3290 -930 3310 -930 {lab=VBIAS}
N 3290 -910 3310 -910 {lab=enb}
N 3610 -910 3630 -910 {lab=DATA4}
N 3460 -830 3460 -810 {lab=AVSS}
N 3390 -830 3390 -810 {lab=ISUM}
N 3460 -1010 3460 -990 {lab=AVDD}
N 3290 -680 3310 -680 {lab=VBIAS}
N 3290 -660 3310 -660 {lab=enb}
N 3610 -660 3630 -660 {lab=DATA4}
N 3460 -580 3460 -560 {lab=AVSS}
N 3390 -580 3390 -560 {lab=ISUM}
N 3460 -760 3460 -740 {lab=AVDD}
N 3290 -430 3310 -430 {lab=VBIAS}
N 3290 -410 3310 -410 {lab=enb}
N 3610 -410 3630 -410 {lab=DATA4}
N 3460 -330 3460 -310 {lab=AVSS}
N 3390 -330 3390 -310 {lab=ISUM}
N 3460 -510 3460 -490 {lab=AVDD}
N 3290 -180 3310 -180 {lab=VBIAS}
N 3290 -160 3310 -160 {lab=enb}
N 3610 -160 3630 -160 {lab=DATA4}
N 3460 -80 3460 -60 {lab=AVSS}
N 3390 -80 3390 -60 {lab=ISUM}
N 3460 -260 3460 -240 {lab=AVDD}
N 3840 -1930 3860 -1930 {lab=VBIAS}
N 3840 -1910 3860 -1910 {lab=enb}
N 4160 -1910 4180 -1910 {lab=DATA4}
N 4010 -1830 4010 -1810 {lab=AVSS}
N 3940 -1830 3940 -1810 {lab=ISUM}
N 4010 -2010 4010 -1990 {lab=AVDD}
N 3840 -1680 3860 -1680 {lab=VBIAS}
N 3840 -1660 3860 -1660 {lab=enb}
N 4160 -1660 4180 -1660 {lab=DATA4}
N 4010 -1580 4010 -1560 {lab=AVSS}
N 3940 -1580 3940 -1560 {lab=ISUM}
N 4010 -1760 4010 -1740 {lab=AVDD}
N 3850 -1440 3870 -1440 {lab=VBIAS}
N 3850 -1420 3870 -1420 {lab=enb}
N 4170 -1420 4190 -1420 {lab=DATA4}
N 4020 -1340 4020 -1320 {lab=AVSS}
N 3950 -1340 3950 -1320 {lab=ISUM}
N 4020 -1520 4020 -1500 {lab=AVDD}
N 3850 -1190 3870 -1190 {lab=VBIAS}
N 3850 -1170 3870 -1170 {lab=enb}
N 4170 -1170 4190 -1170 {lab=DATA4}
N 4020 -1090 4020 -1070 {lab=AVSS}
N 3950 -1090 3950 -1070 {lab=ISUM}
N 4020 -1270 4020 -1250 {lab=AVDD}
N 3850 -950 3870 -950 {lab=VBIAS}
N 3850 -930 3870 -930 {lab=enb}
N 4170 -930 4190 -930 {lab=DATA4}
N 4020 -850 4020 -830 {lab=AVSS}
N 3950 -850 3950 -830 {lab=ISUM}
N 4020 -1030 4020 -1010 {lab=AVDD}
N 3850 -700 3870 -700 {lab=VBIAS}
N 3850 -680 3870 -680 {lab=enb}
N 4170 -680 4190 -680 {lab=DATA4}
N 4020 -600 4020 -580 {lab=AVSS}
N 3950 -600 3950 -580 {lab=ISUM}
N 4020 -780 4020 -760 {lab=AVDD}
N 3860 -460 3880 -460 {lab=VBIAS}
N 3860 -440 3880 -440 {lab=enb}
N 4180 -440 4200 -440 {lab=DATA4}
N 4030 -360 4030 -340 {lab=AVSS}
N 3960 -360 3960 -340 {lab=ISUM}
N 4030 -540 4030 -520 {lab=AVDD}
N 3860 -210 3880 -210 {lab=VBIAS}
N 3860 -190 3880 -190 {lab=enb}
N 4180 -190 4200 -190 {lab=DATA4}
N 4030 -110 4030 -90 {lab=AVSS}
N 3960 -110 3960 -90 {lab=ISUM}
N 4030 -290 4030 -270 {lab=AVDD}
N 4450 -1920 4470 -1920 {lab=VBIAS}
N 4450 -1900 4470 -1900 {lab=enb}
N 4770 -1900 4790 -1900 {lab=DATA4}
N 4620 -1820 4620 -1800 {lab=AVSS}
N 4550 -1820 4550 -1800 {lab=ISUM}
N 4620 -2000 4620 -1980 {lab=AVDD}
N 4460 -1670 4480 -1670 {lab=VBIAS}
N 4460 -1650 4480 -1650 {lab=enb}
N 4780 -1650 4800 -1650 {lab=DATA4}
N 4630 -1570 4630 -1550 {lab=AVSS}
N 4560 -1570 4560 -1550 {lab=ISUM}
N 4630 -1750 4630 -1730 {lab=AVDD}
N 4470 -1420 4490 -1420 {lab=VBIAS}
N 4470 -1400 4490 -1400 {lab=enb}
N 4790 -1400 4810 -1400 {lab=DATA4}
N 4640 -1320 4640 -1300 {lab=AVSS}
N 4570 -1320 4570 -1300 {lab=ISUM}
N 4640 -1500 4640 -1480 {lab=AVDD}
N 4480 -1170 4500 -1170 {lab=VBIAS}
N 4480 -1150 4500 -1150 {lab=enb}
N 4800 -1150 4820 -1150 {lab=DATA4}
N 4650 -1070 4650 -1050 {lab=AVSS}
N 4580 -1070 4580 -1050 {lab=ISUM}
N 4650 -1250 4650 -1230 {lab=AVDD}
N 4480 -940 4500 -940 {lab=VBIAS}
N 4480 -920 4500 -920 {lab=enb}
N 4800 -920 4820 -920 {lab=DATA4}
N 4650 -840 4650 -820 {lab=AVSS}
N 4580 -840 4580 -820 {lab=ISUM}
N 4650 -1020 4650 -1000 {lab=AVDD}
N 4490 -690 4510 -690 {lab=VBIAS}
N 4490 -670 4510 -670 {lab=enb}
N 4810 -670 4830 -670 {lab=DATA4}
N 4660 -590 4660 -570 {lab=AVSS}
N 4590 -590 4590 -570 {lab=ISUM}
N 4660 -770 4660 -750 {lab=AVDD}
N 4500 -440 4520 -440 {lab=VBIAS}
N 4500 -420 4520 -420 {lab=enb}
N 4820 -420 4840 -420 {lab=DATA4}
N 4670 -340 4670 -320 {lab=AVSS}
N 4600 -340 4600 -320 {lab=ISUM}
N 4670 -520 4670 -500 {lab=AVDD}
N 4510 -190 4530 -190 {lab=VBIAS}
N 4510 -170 4530 -170 {lab=enb}
N 4830 -170 4850 -170 {lab=DATA4}
N 4680 -90 4680 -70 {lab=AVSS}
N 4610 -90 4610 -70 {lab=ISUM}
N 4680 -270 4680 -250 {lab=AVDD}
N 5130 -1920 5150 -1920 {lab=VBIAS}
N 5130 -1900 5150 -1900 {lab=enb}
N 5450 -1900 5470 -1900 {lab=DATA4}
N 5300 -1820 5300 -1800 {lab=AVSS}
N 5230 -1820 5230 -1800 {lab=ISUM}
N 5300 -2000 5300 -1980 {lab=AVDD}
N 5140 -1680 5160 -1680 {lab=VBIAS}
N 5140 -1660 5160 -1660 {lab=enb}
N 5460 -1660 5480 -1660 {lab=DATA4}
N 5310 -1580 5310 -1560 {lab=AVSS}
N 5240 -1580 5240 -1560 {lab=ISUM}
N 5310 -1760 5310 -1740 {lab=AVDD}
N 5140 -1430 5160 -1430 {lab=VBIAS}
N 5140 -1410 5160 -1410 {lab=enb}
N 5460 -1410 5480 -1410 {lab=DATA4}
N 5310 -1330 5310 -1310 {lab=AVSS}
N 5240 -1330 5240 -1310 {lab=ISUM}
N 5310 -1510 5310 -1490 {lab=AVDD}
N 5150 -1190 5170 -1190 {lab=VBIAS}
N 5150 -1170 5170 -1170 {lab=enb}
N 5470 -1170 5490 -1170 {lab=DATA4}
N 5320 -1090 5320 -1070 {lab=AVSS}
N 5250 -1090 5250 -1070 {lab=ISUM}
N 5320 -1270 5320 -1250 {lab=AVDD}
N 5150 -950 5170 -950 {lab=VBIAS}
N 5150 -930 5170 -930 {lab=enb}
N 5470 -930 5490 -930 {lab=DATA4}
N 5320 -850 5320 -830 {lab=AVSS}
N 5250 -850 5250 -830 {lab=ISUM}
N 5320 -1030 5320 -1010 {lab=AVDD}
N 5160 -710 5180 -710 {lab=VBIAS}
N 5160 -690 5180 -690 {lab=enb}
N 5480 -690 5500 -690 {lab=DATA4}
N 5330 -610 5330 -590 {lab=AVSS}
N 5260 -610 5260 -590 {lab=ISUM}
N 5330 -790 5330 -770 {lab=AVDD}
N 5160 -460 5180 -460 {lab=VBIAS}
N 5160 -440 5180 -440 {lab=enb}
N 5480 -440 5500 -440 {lab=DATA4}
N 5330 -360 5330 -340 {lab=AVSS}
N 5260 -360 5260 -340 {lab=ISUM}
N 5330 -540 5330 -520 {lab=AVDD}
N 5170 -220 5190 -220 {lab=VBIAS}
N 5170 -200 5190 -200 {lab=enb}
N 5490 -200 5510 -200 {lab=DATA4}
N 5340 -120 5340 -100 {lab=AVSS}
N 5270 -120 5270 -100 {lab=ISUM}
N 5340 -300 5340 -280 {lab=AVDD}
N 5760 -1920 5780 -1920 {lab=VBIAS}
N 5760 -1900 5780 -1900 {lab=enb}
N 6080 -1900 6100 -1900 {lab=DATA4}
N 5930 -1820 5930 -1800 {lab=AVSS}
N 5860 -1820 5860 -1800 {lab=ISUM}
N 5930 -2000 5930 -1980 {lab=AVDD}
N 5760 -1680 5780 -1680 {lab=VBIAS}
N 5760 -1660 5780 -1660 {lab=enb}
N 6080 -1660 6100 -1660 {lab=DATA4}
N 5930 -1580 5930 -1560 {lab=AVSS}
N 5860 -1580 5860 -1560 {lab=ISUM}
N 5930 -1760 5930 -1740 {lab=AVDD}
N 5770 -1440 5790 -1440 {lab=VBIAS}
N 5770 -1420 5790 -1420 {lab=enb}
N 6090 -1420 6110 -1420 {lab=DATA4}
N 5940 -1340 5940 -1320 {lab=AVSS}
N 5870 -1340 5870 -1320 {lab=ISUM}
N 5940 -1520 5940 -1500 {lab=AVDD}
N 5770 -1200 5790 -1200 {lab=VBIAS}
N 5770 -1180 5790 -1180 {lab=enb}
N 6090 -1180 6110 -1180 {lab=DATA4}
N 5940 -1100 5940 -1080 {lab=AVSS}
N 5870 -1100 5870 -1080 {lab=ISUM}
N 5940 -1280 5940 -1260 {lab=AVDD}
N 5770 -950 5790 -950 {lab=VBIAS}
N 5770 -930 5790 -930 {lab=enb}
N 6090 -930 6110 -930 {lab=DATA4}
N 5940 -850 5940 -830 {lab=AVSS}
N 5870 -850 5870 -830 {lab=ISUM}
N 5940 -1030 5940 -1010 {lab=AVDD}
N 5770 -710 5790 -710 {lab=VBIAS}
N 5770 -690 5790 -690 {lab=enb}
N 6090 -690 6110 -690 {lab=DATA4}
N 5940 -610 5940 -590 {lab=AVSS}
N 5870 -610 5870 -590 {lab=ISUM}
N 5940 -790 5940 -770 {lab=AVDD}
N 5780 -470 5800 -470 {lab=VBIAS}
N 5780 -450 5800 -450 {lab=enb}
N 6100 -450 6120 -450 {lab=DATA4}
N 5950 -370 5950 -350 {lab=AVSS}
N 5880 -370 5880 -350 {lab=ISUM}
N 5950 -550 5950 -530 {lab=AVDD}
N 5780 -230 5800 -230 {lab=VBIAS}
N 5780 -210 5800 -210 {lab=enb}
N 6100 -210 6120 -210 {lab=DATA4}
N 5950 -130 5950 -110 {lab=AVSS}
N 5880 -130 5880 -110 {lab=ISUM}
N 5950 -310 5950 -290 {lab=AVDD}
N 6400 -1910 6420 -1910 {lab=VBIAS}
N 6400 -1890 6420 -1890 {lab=enb}
N 6720 -1890 6740 -1890 {lab=DATA4}
N 6570 -1810 6570 -1790 {lab=AVSS}
N 6500 -1810 6500 -1790 {lab=ISUM}
N 6570 -1990 6570 -1970 {lab=AVDD}
N 6400 -1680 6420 -1680 {lab=VBIAS}
N 6400 -1660 6420 -1660 {lab=enb}
N 6720 -1660 6740 -1660 {lab=DATA4}
N 6570 -1580 6570 -1560 {lab=AVSS}
N 6500 -1580 6500 -1560 {lab=ISUM}
N 6570 -1760 6570 -1740 {lab=AVDD}
N 6410 -1440 6430 -1440 {lab=VBIAS}
N 6410 -1420 6430 -1420 {lab=enb}
N 6730 -1420 6750 -1420 {lab=DATA4}
N 6580 -1340 6580 -1320 {lab=AVSS}
N 6510 -1340 6510 -1320 {lab=ISUM}
N 6580 -1520 6580 -1500 {lab=AVDD}
N 6410 -1210 6430 -1210 {lab=VBIAS}
N 6410 -1190 6430 -1190 {lab=enb}
N 6730 -1190 6750 -1190 {lab=DATA4}
N 6580 -1110 6580 -1090 {lab=AVSS}
N 6510 -1110 6510 -1090 {lab=ISUM}
N 6580 -1290 6580 -1270 {lab=AVDD}
N 6420 -970 6440 -970 {lab=VBIAS}
N 6420 -950 6440 -950 {lab=enb}
N 6740 -950 6760 -950 {lab=DATA4}
N 6590 -870 6590 -850 {lab=AVSS}
N 6520 -870 6520 -850 {lab=ISUM}
N 6590 -1050 6590 -1030 {lab=AVDD}
N 6420 -740 6440 -740 {lab=VBIAS}
N 6420 -720 6440 -720 {lab=enb}
N 6740 -720 6760 -720 {lab=DATA4}
N 6590 -640 6590 -620 {lab=AVSS}
N 6520 -640 6520 -620 {lab=ISUM}
N 6590 -820 6590 -800 {lab=AVDD}
N 6430 -500 6450 -500 {lab=VBIAS}
N 6430 -480 6450 -480 {lab=enb}
N 6750 -480 6770 -480 {lab=DATA4}
N 6600 -400 6600 -380 {lab=AVSS}
N 6530 -400 6530 -380 {lab=ISUM}
N 6600 -580 6600 -560 {lab=AVDD}
N 6430 -270 6450 -270 {lab=VBIAS}
N 6430 -250 6450 -250 {lab=enb}
N 6750 -250 6770 -250 {lab=DATA4}
N 6600 -170 6600 -150 {lab=AVSS}
N 6530 -170 6530 -150 {lab=ISUM}
N 6600 -350 6600 -330 {lab=AVDD}
N 7010 -1910 7030 -1910 {lab=VBIAS}
N 7010 -1890 7030 -1890 {lab=enb}
N 7330 -1890 7350 -1890 {lab=DATA4}
N 7180 -1810 7180 -1790 {lab=AVSS}
N 7110 -1810 7110 -1790 {lab=ISUM}
N 7180 -1990 7180 -1970 {lab=AVDD}
N 7010 -1680 7030 -1680 {lab=VBIAS}
N 7010 -1660 7030 -1660 {lab=enb}
N 7330 -1660 7350 -1660 {lab=DATA4}
N 7180 -1580 7180 -1560 {lab=AVSS}
N 7110 -1580 7110 -1560 {lab=ISUM}
N 7180 -1760 7180 -1740 {lab=AVDD}
N 7010 -1430 7030 -1430 {lab=VBIAS}
N 7010 -1410 7030 -1410 {lab=enb}
N 7330 -1410 7350 -1410 {lab=DATA4}
N 7180 -1330 7180 -1310 {lab=AVSS}
N 7110 -1330 7110 -1310 {lab=ISUM}
N 7180 -1510 7180 -1490 {lab=AVDD}
N 7010 -1200 7030 -1200 {lab=VBIAS}
N 7010 -1180 7030 -1180 {lab=enb}
N 7330 -1180 7350 -1180 {lab=DATA4}
N 7180 -1100 7180 -1080 {lab=AVSS}
N 7110 -1100 7110 -1080 {lab=ISUM}
N 7180 -1280 7180 -1260 {lab=AVDD}
N 7020 -950 7040 -950 {lab=VBIAS}
N 7020 -930 7040 -930 {lab=enb}
N 7340 -930 7360 -930 {lab=DATA4}
N 7190 -850 7190 -830 {lab=AVSS}
N 7120 -850 7120 -830 {lab=ISUM}
N 7190 -1030 7190 -1010 {lab=AVDD}
N 7020 -720 7040 -720 {lab=VBIAS}
N 7020 -700 7040 -700 {lab=enb}
N 7340 -700 7360 -700 {lab=DATA4}
N 7190 -620 7190 -600 {lab=AVSS}
N 7120 -620 7120 -600 {lab=ISUM}
N 7190 -800 7190 -780 {lab=AVDD}
N 7020 -470 7040 -470 {lab=VBIAS}
N 7020 -450 7040 -450 {lab=enb}
N 7340 -450 7360 -450 {lab=DATA4}
N 7190 -370 7190 -350 {lab=AVSS}
N 7120 -370 7120 -350 {lab=ISUM}
N 7190 -550 7190 -530 {lab=AVDD}
N 7020 -240 7040 -240 {lab=VBIAS}
N 7020 -220 7040 -220 {lab=enb}
N 7340 -220 7360 -220 {lab=DATA4}
N 7190 -140 7190 -120 {lab=AVSS}
N 7120 -140 7120 -120 {lab=ISUM}
N 7190 -320 7190 -300 {lab=AVDD}
N 7540 -1900 7560 -1900 {lab=VBIAS}
N 7540 -1880 7560 -1880 {lab=enb}
N 7860 -1880 7880 -1880 {lab=DATA4}
N 7710 -1800 7710 -1780 {lab=AVSS}
N 7640 -1800 7640 -1780 {lab=ISUM}
N 7710 -1980 7710 -1960 {lab=AVDD}
N 7540 -1660 7560 -1660 {lab=VBIAS}
N 7540 -1640 7560 -1640 {lab=enb}
N 7860 -1640 7880 -1640 {lab=DATA4}
N 7710 -1560 7710 -1540 {lab=AVSS}
N 7640 -1560 7640 -1540 {lab=ISUM}
N 7710 -1740 7710 -1720 {lab=AVDD}
N 7540 -1420 7560 -1420 {lab=VBIAS}
N 7540 -1400 7560 -1400 {lab=enb}
N 7860 -1400 7880 -1400 {lab=DATA4}
N 7710 -1320 7710 -1300 {lab=AVSS}
N 7640 -1320 7640 -1300 {lab=ISUM}
N 7710 -1500 7710 -1480 {lab=AVDD}
N 7540 -1180 7560 -1180 {lab=VBIAS}
N 7540 -1160 7560 -1160 {lab=enb}
N 7860 -1160 7880 -1160 {lab=DATA4}
N 7710 -1080 7710 -1060 {lab=AVSS}
N 7640 -1080 7640 -1060 {lab=ISUM}
N 7710 -1260 7710 -1240 {lab=AVDD}
N 7540 -940 7560 -940 {lab=VBIAS}
N 7540 -920 7560 -920 {lab=enb}
N 7860 -920 7880 -920 {lab=DATA4}
N 7710 -840 7710 -820 {lab=AVSS}
N 7640 -840 7640 -820 {lab=ISUM}
N 7710 -1020 7710 -1000 {lab=AVDD}
N 7540 -700 7560 -700 {lab=VBIAS}
N 7540 -680 7560 -680 {lab=enb}
N 7860 -680 7880 -680 {lab=DATA4}
N 7710 -600 7710 -580 {lab=AVSS}
N 7640 -600 7640 -580 {lab=ISUM}
N 7710 -780 7710 -760 {lab=AVDD}
N 7540 -460 7560 -460 {lab=VBIAS}
N 7540 -440 7560 -440 {lab=enb}
N 7860 -440 7880 -440 {lab=DATA4}
N 7710 -360 7710 -340 {lab=AVSS}
N 7640 -360 7640 -340 {lab=ISUM}
N 7710 -540 7710 -520 {lab=AVDD}
N 7540 -220 7560 -220 {lab=VBIAS}
N 7540 -200 7560 -200 {lab=enb}
N 7860 -200 7880 -200 {lab=DATA4}
N 7710 -120 7710 -100 {lab=AVSS}
N 7640 -120 7640 -100 {lab=ISUM}
N 7710 -300 7710 -280 {lab=AVDD}
N 8130 -1900 8150 -1900 {lab=VBIAS}
N 8130 -1880 8150 -1880 {lab=enb}
N 8450 -1880 8470 -1880 {lab=DATA4}
N 8300 -1800 8300 -1780 {lab=AVSS}
N 8230 -1800 8230 -1780 {lab=ISUM}
N 8300 -1980 8300 -1960 {lab=AVDD}
N 8130 -1660 8150 -1660 {lab=VBIAS}
N 8130 -1640 8150 -1640 {lab=enb}
N 8450 -1640 8470 -1640 {lab=DATA4}
N 8300 -1560 8300 -1540 {lab=AVSS}
N 8230 -1560 8230 -1540 {lab=ISUM}
N 8300 -1740 8300 -1720 {lab=AVDD}
N 8140 -1400 8160 -1400 {lab=VBIAS}
N 8140 -1380 8160 -1380 {lab=enb}
N 8460 -1380 8480 -1380 {lab=DATA4}
N 8310 -1300 8310 -1280 {lab=AVSS}
N 8240 -1300 8240 -1280 {lab=ISUM}
N 8310 -1480 8310 -1460 {lab=AVDD}
N 8140 -1160 8160 -1160 {lab=VBIAS}
N 8140 -1140 8160 -1140 {lab=enb}
N 8460 -1140 8480 -1140 {lab=DATA4}
N 8310 -1060 8310 -1040 {lab=AVSS}
N 8240 -1060 8240 -1040 {lab=ISUM}
N 8310 -1240 8310 -1220 {lab=AVDD}
N 8150 -920 8170 -920 {lab=VBIAS}
N 8150 -900 8170 -900 {lab=enb}
N 8470 -900 8490 -900 {lab=DATA4}
N 8320 -820 8320 -800 {lab=AVSS}
N 8250 -820 8250 -800 {lab=ISUM}
N 8320 -1000 8320 -980 {lab=AVDD}
N 8150 -680 8170 -680 {lab=VBIAS}
N 8150 -660 8170 -660 {lab=enb}
N 8470 -660 8490 -660 {lab=DATA4}
N 8320 -580 8320 -560 {lab=AVSS}
N 8250 -580 8250 -560 {lab=ISUM}
N 8320 -760 8320 -740 {lab=AVDD}
N 8160 -420 8180 -420 {lab=VBIAS}
N 8160 -400 8180 -400 {lab=enb}
N 8480 -400 8500 -400 {lab=DATA4}
N 8330 -320 8330 -300 {lab=AVSS}
N 8260 -320 8260 -300 {lab=ISUM}
N 8330 -500 8330 -480 {lab=AVDD}
N 8160 -180 8180 -180 {lab=VBIAS}
N 8160 -160 8180 -160 {lab=enb}
N 8480 -160 8500 -160 {lab=DATA4}
N 8330 -80 8330 -60 {lab=AVSS}
N 8260 -80 8260 -60 {lab=ISUM}
N 8330 -260 8330 -240 {lab=AVDD}
N 340 -2410 390 -2410 {lab=AVDD}
N 340 -2380 390 -2380 {lab=AVSS}
N 340 -2350 390 -2350 {lab=VBIAS}
N 530 -2410 580 -2410 {lab=DATA3}
N 340 -2320 390 -2320 {lab=en_bb}
N 340 -2290 390 -2290 {lab=ISUM}
N 530 -2380 580 -2380 {lab=DATA4}
N 530 -2350 580 -2350 {lab=DATA5}
N 530 -2320 580 -2320 {lab=DATA6}
N 530 -2290 580 -2290 {lab=DATA7}
N 690 -2410 740 -2410 {lab=DATA8}
N 690 -2380 740 -2380 {lab=DATA9}
N 690 -2350 740 -2350 {lab=DATA10}
N 690 -2320 740 -2320 {lab=DATA11}
N 690 -2290 740 -2290 {lab=DATA12}
N 850 -2410 900 -2410 {lab=DATA13}
N 850 -2380 900 -2380 {lab=DATA14}
N 850 -2350 900 -2350 {lab=DATA15}
N 850 -2320 900 -2320 {lab=DATA16}
N 850 -2290 900 -2290 {lab=DATA17}
C {dac.sym} 270 -1880 0 0 {name=x1}
C {lab_wire.sym} 270 -1970 0 0 {name=p16 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -1780 0 1 {name=p13 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -1880 0 1 {name=p14 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -1900 0 0 {name=p28 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -1780 0 0 {name=p35 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -1880 0 0 {name=p42 sig_type=std_logic lab=enb}
C {dac.sym} 270 -1650 0 0 {name=x2}
C {lab_wire.sym} 270 -1740 0 0 {name=p1 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -1550 0 1 {name=p2 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -1650 0 1 {name=p3 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -1670 0 0 {name=p4 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -1550 0 0 {name=p5 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -1650 0 0 {name=p6 sig_type=std_logic lab=enb}
C {dac.sym} 270 -1420 0 0 {name=x3}
C {lab_wire.sym} 270 -1510 0 0 {name=p7 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -1320 0 1 {name=p8 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -1420 0 1 {name=p9 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -1440 0 0 {name=p10 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -1320 0 0 {name=p11 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -1420 0 0 {name=p12 sig_type=std_logic lab=enb}
C {dac.sym} 270 -1180 0 0 {name=x4}
C {lab_wire.sym} 270 -1270 0 0 {name=p15 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -1080 0 1 {name=p17 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -1180 0 1 {name=p18 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -1200 0 0 {name=p19 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -1080 0 0 {name=p20 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -1180 0 0 {name=p21 sig_type=std_logic lab=enb}
C {dac.sym} 270 -920 0 0 {name=x5}
C {lab_wire.sym} 270 -1010 0 0 {name=p22 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -820 0 1 {name=p23 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -920 0 1 {name=p24 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -940 0 0 {name=p25 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -820 0 0 {name=p26 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -920 0 0 {name=p27 sig_type=std_logic lab=enb}
C {dac.sym} 270 -690 0 0 {name=x6}
C {lab_wire.sym} 270 -780 0 0 {name=p29 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -590 0 1 {name=p30 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -690 0 1 {name=p31 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -710 0 0 {name=p32 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -590 0 0 {name=p33 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -690 0 0 {name=p34 sig_type=std_logic lab=enb}
C {dac.sym} 270 -460 0 0 {name=x7}
C {lab_wire.sym} 270 -550 0 0 {name=p36 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -360 0 1 {name=p37 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -460 0 1 {name=p38 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -480 0 0 {name=p39 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -360 0 0 {name=p40 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -460 0 0 {name=p41 sig_type=std_logic lab=enb}
C {dac.sym} 270 -220 0 0 {name=x8}
C {lab_wire.sym} 270 -310 0 0 {name=p43 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 270 -120 0 1 {name=p44 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 430 -220 0 1 {name=p45 sig_type=std_logic lab=DATA3}
C {lab_wire.sym} 110 -240 0 0 {name=p46 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 200 -120 0 0 {name=p47 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 100 -220 0 0 {name=p48 sig_type=std_logic lab=enb}
C {dac.sym} 780 -1880 0 0 {name=x9}
C {lab_wire.sym} 780 -1970 0 0 {name=p49 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 780 -1780 0 1 {name=p50 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 940 -1880 0 1 {name=p51 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 620 -1900 0 0 {name=p52 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 710 -1780 0 0 {name=p53 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 610 -1880 0 0 {name=p54 sig_type=std_logic lab=enb}
C {dac.sym} 780 -1650 0 0 {name=x10}
C {lab_wire.sym} 780 -1740 0 0 {name=p55 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 780 -1550 0 1 {name=p56 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 940 -1650 0 1 {name=p57 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 620 -1670 0 0 {name=p58 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 710 -1550 0 0 {name=p59 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 610 -1650 0 0 {name=p60 sig_type=std_logic lab=enb}
C {dac.sym} 790 -1420 0 0 {name=x11}
C {lab_wire.sym} 790 -1510 0 0 {name=p61 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 790 -1320 0 1 {name=p62 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 950 -1420 0 1 {name=p63 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 630 -1440 0 0 {name=p64 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 720 -1320 0 0 {name=p65 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 620 -1420 0 0 {name=p66 sig_type=std_logic lab=enb}
C {dac.sym} 790 -1190 0 0 {name=x12}
C {lab_wire.sym} 790 -1280 0 0 {name=p67 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 790 -1090 0 1 {name=p68 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 950 -1190 0 1 {name=p69 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 630 -1210 0 0 {name=p70 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 720 -1090 0 0 {name=p71 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 620 -1190 0 0 {name=p72 sig_type=std_logic lab=enb}
C {dac.sym} 790 -910 0 0 {name=x13}
C {lab_wire.sym} 790 -1000 0 0 {name=p73 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 790 -810 0 1 {name=p74 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 950 -910 0 1 {name=p75 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 630 -930 0 0 {name=p76 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 720 -810 0 0 {name=p77 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 620 -910 0 0 {name=p78 sig_type=std_logic lab=enb}
C {dac.sym} 790 -680 0 0 {name=x14}
C {lab_wire.sym} 790 -770 0 0 {name=p79 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 790 -580 0 1 {name=p80 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 950 -680 0 1 {name=p81 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 630 -700 0 0 {name=p82 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 720 -580 0 0 {name=p83 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 620 -680 0 0 {name=p84 sig_type=std_logic lab=enb}
C {dac.sym} 800 -450 0 0 {name=x15}
C {lab_wire.sym} 800 -540 0 0 {name=p85 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 800 -350 0 1 {name=p86 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 960 -450 0 1 {name=p87 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 640 -470 0 0 {name=p88 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 730 -350 0 0 {name=p89 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 630 -450 0 0 {name=p90 sig_type=std_logic lab=enb}
C {dac.sym} 800 -220 0 0 {name=x16}
C {lab_wire.sym} 800 -310 0 0 {name=p91 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 800 -120 0 1 {name=p92 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 960 -220 0 1 {name=p93 sig_type=std_logic lab=DATA4}
C {lab_wire.sym} 640 -240 0 0 {name=p94 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 730 -120 0 0 {name=p95 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 630 -220 0 0 {name=p96 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -1880 0 0 {name=x17}
C {lab_wire.sym} 1330 -1970 0 0 {name=p97 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -1780 0 1 {name=p98 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -1880 0 1 {name=p99 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -1900 0 0 {name=p100 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -1780 0 0 {name=p101 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -1880 0 0 {name=p102 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -1640 0 0 {name=x18}
C {lab_wire.sym} 1330 -1730 0 0 {name=p103 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -1540 0 1 {name=p104 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -1640 0 1 {name=p105 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -1660 0 0 {name=p106 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -1540 0 0 {name=p107 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -1640 0 0 {name=p108 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -1390 0 0 {name=x19}
C {lab_wire.sym} 1330 -1480 0 0 {name=p109 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -1290 0 1 {name=p110 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -1390 0 1 {name=p111 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -1410 0 0 {name=p112 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -1290 0 0 {name=p113 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -1390 0 0 {name=p114 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -1150 0 0 {name=x20}
C {lab_wire.sym} 1330 -1240 0 0 {name=p115 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -1050 0 1 {name=p116 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -1150 0 1 {name=p117 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -1170 0 0 {name=p118 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -1050 0 0 {name=p119 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -1150 0 0 {name=p120 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -920 0 0 {name=x21}
C {lab_wire.sym} 1330 -1010 0 0 {name=p121 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -820 0 1 {name=p122 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -920 0 1 {name=p123 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -940 0 0 {name=p124 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -820 0 0 {name=p125 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -920 0 0 {name=p126 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -680 0 0 {name=x22}
C {lab_wire.sym} 1330 -770 0 0 {name=p127 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -580 0 1 {name=p128 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -680 0 1 {name=p129 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -700 0 0 {name=p130 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -580 0 0 {name=p131 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -680 0 0 {name=p132 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -430 0 0 {name=x23}
C {lab_wire.sym} 1330 -520 0 0 {name=p133 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -330 0 1 {name=p134 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -430 0 1 {name=p135 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -450 0 0 {name=p136 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -330 0 0 {name=p137 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -430 0 0 {name=p138 sig_type=std_logic lab=enb}
C {dac.sym} 1330 -190 0 0 {name=x24}
C {lab_wire.sym} 1330 -280 0 0 {name=p139 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -90 0 1 {name=p140 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1490 -190 0 1 {name=p141 sig_type=std_logic lab=DATA5}
C {lab_wire.sym} 1170 -210 0 0 {name=p142 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1260 -90 0 0 {name=p143 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1160 -190 0 0 {name=p144 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -1880 0 0 {name=x25}
C {lab_wire.sym} 1820 -1970 0 0 {name=p145 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -1780 0 1 {name=p146 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -1880 0 1 {name=p147 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -1900 0 0 {name=p148 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -1780 0 0 {name=p149 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -1880 0 0 {name=p150 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -1650 0 0 {name=x26}
C {lab_wire.sym} 1820 -1740 0 0 {name=p151 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -1550 0 1 {name=p152 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -1650 0 1 {name=p153 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -1670 0 0 {name=p154 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -1550 0 0 {name=p155 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -1650 0 0 {name=p156 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -1400 0 0 {name=x27}
C {lab_wire.sym} 1820 -1490 0 0 {name=p157 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -1300 0 1 {name=p158 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -1400 0 1 {name=p159 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -1420 0 0 {name=p160 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -1300 0 0 {name=p161 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -1400 0 0 {name=p162 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -1170 0 0 {name=x28}
C {lab_wire.sym} 1820 -1260 0 0 {name=p163 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -1070 0 1 {name=p164 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -1170 0 1 {name=p165 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -1190 0 0 {name=p166 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -1070 0 0 {name=p167 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -1170 0 0 {name=p168 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -920 0 0 {name=x29}
C {lab_wire.sym} 1820 -1010 0 0 {name=p169 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -820 0 1 {name=p170 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -920 0 1 {name=p171 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -940 0 0 {name=p172 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -820 0 0 {name=p173 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -920 0 0 {name=p174 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -690 0 0 {name=x30}
C {lab_wire.sym} 1820 -780 0 0 {name=p175 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -590 0 1 {name=p176 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -690 0 1 {name=p177 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -710 0 0 {name=p178 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -590 0 0 {name=p179 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -690 0 0 {name=p180 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -440 0 0 {name=x31}
C {lab_wire.sym} 1820 -530 0 0 {name=p181 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -340 0 1 {name=p182 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -440 0 1 {name=p183 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -460 0 0 {name=p184 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -340 0 0 {name=p185 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -440 0 0 {name=p186 sig_type=std_logic lab=enb}
C {dac.sym} 1820 -210 0 0 {name=x32}
C {lab_wire.sym} 1820 -300 0 0 {name=p187 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1820 -110 0 1 {name=p188 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -210 0 1 {name=p189 sig_type=std_logic lab=DATA6}
C {lab_wire.sym} 1660 -230 0 0 {name=p190 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1750 -110 0 0 {name=p191 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 1650 -210 0 0 {name=p192 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -1880 0 0 {name=x33}
C {lab_wire.sym} 2330 -1970 0 0 {name=p193 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -1780 0 1 {name=p194 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -1880 0 1 {name=p195 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -1900 0 0 {name=p196 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -1780 0 0 {name=p197 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -1880 0 0 {name=p198 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -1640 0 0 {name=x34}
C {lab_wire.sym} 2330 -1730 0 0 {name=p199 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -1540 0 1 {name=p200 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -1640 0 1 {name=p201 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -1660 0 0 {name=p202 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -1540 0 0 {name=p203 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -1640 0 0 {name=p204 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -1390 0 0 {name=x35}
C {lab_wire.sym} 2330 -1480 0 0 {name=p205 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -1290 0 1 {name=p206 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -1390 0 1 {name=p207 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -1410 0 0 {name=p208 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -1290 0 0 {name=p209 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -1390 0 0 {name=p210 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -1150 0 0 {name=x36}
C {lab_wire.sym} 2330 -1240 0 0 {name=p211 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -1050 0 1 {name=p212 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -1150 0 1 {name=p213 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -1170 0 0 {name=p214 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -1050 0 0 {name=p215 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -1150 0 0 {name=p216 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -920 0 0 {name=x37}
C {lab_wire.sym} 2330 -1010 0 0 {name=p217 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -820 0 1 {name=p218 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -920 0 1 {name=p219 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -940 0 0 {name=p220 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -820 0 0 {name=p221 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -920 0 0 {name=p222 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -680 0 0 {name=x38}
C {lab_wire.sym} 2330 -770 0 0 {name=p223 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -580 0 1 {name=p224 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -680 0 1 {name=p225 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -700 0 0 {name=p226 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -580 0 0 {name=p227 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -680 0 0 {name=p228 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -430 0 0 {name=x39}
C {lab_wire.sym} 2330 -520 0 0 {name=p229 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -330 0 1 {name=p230 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -430 0 1 {name=p231 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -450 0 0 {name=p232 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -330 0 0 {name=p233 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -430 0 0 {name=p234 sig_type=std_logic lab=enb}
C {dac.sym} 2330 -190 0 0 {name=x40}
C {lab_wire.sym} 2330 -280 0 0 {name=p235 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2330 -90 0 1 {name=p236 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -190 0 1 {name=p237 sig_type=std_logic lab=DATA7}
C {lab_wire.sym} 2170 -210 0 0 {name=p238 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2260 -90 0 0 {name=p239 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2160 -190 0 0 {name=p240 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -1910 0 0 {name=x41}
C {lab_wire.sym} 2900 -2000 0 0 {name=p241 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -1810 0 1 {name=p242 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -1910 0 1 {name=p243 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -1930 0 0 {name=p244 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -1810 0 0 {name=p245 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -1910 0 0 {name=p246 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -1660 0 0 {name=x42}
C {lab_wire.sym} 2900 -1750 0 0 {name=p247 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -1560 0 1 {name=p248 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -1660 0 1 {name=p249 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -1680 0 0 {name=p250 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -1560 0 0 {name=p251 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -1660 0 0 {name=p252 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -1420 0 0 {name=x43}
C {lab_wire.sym} 2900 -1510 0 0 {name=p253 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -1320 0 1 {name=p254 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -1420 0 1 {name=p255 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -1440 0 0 {name=p256 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -1320 0 0 {name=p257 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -1420 0 0 {name=p258 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -1170 0 0 {name=x44}
C {lab_wire.sym} 2900 -1260 0 0 {name=p259 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -1070 0 1 {name=p260 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -1170 0 1 {name=p261 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -1190 0 0 {name=p262 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -1070 0 0 {name=p263 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -1170 0 0 {name=p264 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -920 0 0 {name=x45}
C {lab_wire.sym} 2900 -1010 0 0 {name=p265 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -820 0 1 {name=p266 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -920 0 1 {name=p267 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -940 0 0 {name=p268 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -820 0 0 {name=p269 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -920 0 0 {name=p270 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -670 0 0 {name=x46}
C {lab_wire.sym} 2900 -760 0 0 {name=p271 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -570 0 1 {name=p272 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -670 0 1 {name=p273 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -690 0 0 {name=p274 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -570 0 0 {name=p275 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -670 0 0 {name=p276 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -430 0 0 {name=x47}
C {lab_wire.sym} 2900 -520 0 0 {name=p277 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -330 0 1 {name=p278 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -430 0 1 {name=p279 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -450 0 0 {name=p280 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -330 0 0 {name=p281 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -430 0 0 {name=p282 sig_type=std_logic lab=enb}
C {dac.sym} 2900 -180 0 0 {name=x48}
C {lab_wire.sym} 2900 -270 0 0 {name=p283 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2900 -80 0 1 {name=p284 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3060 -180 0 1 {name=p285 sig_type=std_logic lab=DATA8}
C {lab_wire.sym} 2740 -200 0 0 {name=p286 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2830 -80 0 0 {name=p287 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2730 -180 0 0 {name=p288 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -1910 0 0 {name=x49}
C {lab_wire.sym} 3460 -2000 0 0 {name=p289 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -1810 0 1 {name=p290 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -1910 0 1 {name=p291 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -1930 0 0 {name=p292 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -1810 0 0 {name=p293 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -1910 0 0 {name=p294 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -1660 0 0 {name=x50}
C {lab_wire.sym} 3460 -1750 0 0 {name=p295 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -1560 0 1 {name=p296 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -1660 0 1 {name=p297 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -1680 0 0 {name=p298 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -1560 0 0 {name=p299 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -1660 0 0 {name=p300 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -1410 0 0 {name=x51}
C {lab_wire.sym} 3460 -1500 0 0 {name=p301 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -1310 0 1 {name=p302 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -1410 0 1 {name=p303 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -1430 0 0 {name=p304 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -1310 0 0 {name=p305 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -1410 0 0 {name=p306 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -1160 0 0 {name=x52}
C {lab_wire.sym} 3460 -1250 0 0 {name=p307 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -1060 0 1 {name=p308 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -1160 0 1 {name=p309 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -1180 0 0 {name=p310 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -1060 0 0 {name=p311 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -1160 0 0 {name=p312 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -910 0 0 {name=x53}
C {lab_wire.sym} 3460 -1000 0 0 {name=p313 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -810 0 1 {name=p314 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -910 0 1 {name=p315 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -930 0 0 {name=p316 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -810 0 0 {name=p317 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -910 0 0 {name=p318 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -660 0 0 {name=x54}
C {lab_wire.sym} 3460 -750 0 0 {name=p319 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -560 0 1 {name=p320 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -660 0 1 {name=p321 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -680 0 0 {name=p322 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -560 0 0 {name=p323 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -660 0 0 {name=p324 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -410 0 0 {name=x55}
C {lab_wire.sym} 3460 -500 0 0 {name=p325 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -310 0 1 {name=p326 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -410 0 1 {name=p327 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -430 0 0 {name=p328 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -310 0 0 {name=p329 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -410 0 0 {name=p330 sig_type=std_logic lab=enb}
C {dac.sym} 3460 -160 0 0 {name=x56}
C {lab_wire.sym} 3460 -250 0 0 {name=p331 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3460 -60 0 1 {name=p332 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3620 -160 0 1 {name=p333 sig_type=std_logic lab=DATA9}
C {lab_wire.sym} 3300 -180 0 0 {name=p334 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3390 -60 0 0 {name=p335 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3290 -160 0 0 {name=p336 sig_type=std_logic lab=enb}
C {dac.sym} 4010 -1910 0 0 {name=x57}
C {lab_wire.sym} 4010 -2000 0 0 {name=p337 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4010 -1810 0 1 {name=p338 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4170 -1910 0 1 {name=p339 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3850 -1930 0 0 {name=p340 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3940 -1810 0 0 {name=p341 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3840 -1910 0 0 {name=p342 sig_type=std_logic lab=enb}
C {dac.sym} 4010 -1660 0 0 {name=x58}
C {lab_wire.sym} 4010 -1750 0 0 {name=p343 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4010 -1560 0 1 {name=p344 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4170 -1660 0 1 {name=p345 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3850 -1680 0 0 {name=p346 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3940 -1560 0 0 {name=p347 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3840 -1660 0 0 {name=p348 sig_type=std_logic lab=enb}
C {dac.sym} 4020 -1420 0 0 {name=x59}
C {lab_wire.sym} 4020 -1510 0 0 {name=p349 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4020 -1320 0 1 {name=p350 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4180 -1420 0 1 {name=p351 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3860 -1440 0 0 {name=p352 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3950 -1320 0 0 {name=p353 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3850 -1420 0 0 {name=p354 sig_type=std_logic lab=enb}
C {dac.sym} 4020 -1170 0 0 {name=x60}
C {lab_wire.sym} 4020 -1260 0 0 {name=p355 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4020 -1070 0 1 {name=p356 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4180 -1170 0 1 {name=p357 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3860 -1190 0 0 {name=p358 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3950 -1070 0 0 {name=p359 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3850 -1170 0 0 {name=p360 sig_type=std_logic lab=enb}
C {dac.sym} 4020 -930 0 0 {name=x61}
C {lab_wire.sym} 4020 -1020 0 0 {name=p361 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4020 -830 0 1 {name=p362 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4180 -930 0 1 {name=p363 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3860 -950 0 0 {name=p364 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3950 -830 0 0 {name=p365 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3850 -930 0 0 {name=p366 sig_type=std_logic lab=enb}
C {dac.sym} 4020 -680 0 0 {name=x62}
C {lab_wire.sym} 4020 -770 0 0 {name=p367 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4020 -580 0 1 {name=p368 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4180 -680 0 1 {name=p369 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3860 -700 0 0 {name=p370 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3950 -580 0 0 {name=p371 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3850 -680 0 0 {name=p372 sig_type=std_logic lab=enb}
C {dac.sym} 4030 -440 0 0 {name=x63}
C {lab_wire.sym} 4030 -530 0 0 {name=p373 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4030 -340 0 1 {name=p374 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4190 -440 0 1 {name=p375 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3870 -460 0 0 {name=p376 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3960 -340 0 0 {name=p377 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3860 -440 0 0 {name=p378 sig_type=std_logic lab=enb}
C {dac.sym} 4030 -190 0 0 {name=x64}
C {lab_wire.sym} 4030 -280 0 0 {name=p379 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4030 -90 0 1 {name=p380 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4190 -190 0 1 {name=p381 sig_type=std_logic lab=DATA10}
C {lab_wire.sym} 3870 -210 0 0 {name=p382 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3960 -90 0 0 {name=p383 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3860 -190 0 0 {name=p384 sig_type=std_logic lab=enb}
C {dac.sym} 4620 -1900 0 0 {name=x65}
C {lab_wire.sym} 4620 -1990 0 0 {name=p385 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4620 -1800 0 1 {name=p386 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4780 -1900 0 1 {name=p387 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4460 -1920 0 0 {name=p388 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4550 -1800 0 0 {name=p389 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4450 -1900 0 0 {name=p390 sig_type=std_logic lab=enb}
C {dac.sym} 4630 -1650 0 0 {name=x66}
C {lab_wire.sym} 4630 -1740 0 0 {name=p391 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4630 -1550 0 1 {name=p392 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4790 -1650 0 1 {name=p393 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4470 -1670 0 0 {name=p394 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4560 -1550 0 0 {name=p395 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4460 -1650 0 0 {name=p396 sig_type=std_logic lab=enb}
C {dac.sym} 4640 -1400 0 0 {name=x67}
C {lab_wire.sym} 4640 -1490 0 0 {name=p397 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4640 -1300 0 1 {name=p398 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4800 -1400 0 1 {name=p399 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4480 -1420 0 0 {name=p400 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4570 -1300 0 0 {name=p401 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4470 -1400 0 0 {name=p402 sig_type=std_logic lab=enb}
C {dac.sym} 4650 -1150 0 0 {name=x68}
C {lab_wire.sym} 4650 -1240 0 0 {name=p403 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4650 -1050 0 1 {name=p404 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4810 -1150 0 1 {name=p405 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4490 -1170 0 0 {name=p406 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4580 -1050 0 0 {name=p407 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4480 -1150 0 0 {name=p408 sig_type=std_logic lab=enb}
C {dac.sym} 4650 -920 0 0 {name=x69}
C {lab_wire.sym} 4650 -1010 0 0 {name=p409 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4650 -820 0 1 {name=p410 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4810 -920 0 1 {name=p411 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4490 -940 0 0 {name=p412 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4580 -820 0 0 {name=p413 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4480 -920 0 0 {name=p414 sig_type=std_logic lab=enb}
C {dac.sym} 4660 -670 0 0 {name=x70}
C {lab_wire.sym} 4660 -760 0 0 {name=p415 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4660 -570 0 1 {name=p416 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4820 -670 0 1 {name=p417 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4500 -690 0 0 {name=p418 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4590 -570 0 0 {name=p419 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4490 -670 0 0 {name=p420 sig_type=std_logic lab=enb}
C {dac.sym} 4670 -420 0 0 {name=x71}
C {lab_wire.sym} 4670 -510 0 0 {name=p421 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4670 -320 0 1 {name=p422 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4830 -420 0 1 {name=p423 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4510 -440 0 0 {name=p424 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4600 -320 0 0 {name=p425 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4500 -420 0 0 {name=p426 sig_type=std_logic lab=enb}
C {dac.sym} 4680 -170 0 0 {name=x72}
C {lab_wire.sym} 4680 -260 0 0 {name=p427 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4680 -70 0 1 {name=p428 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4840 -170 0 1 {name=p429 sig_type=std_logic lab=DATA11}
C {lab_wire.sym} 4520 -190 0 0 {name=p430 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4610 -70 0 0 {name=p431 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4510 -170 0 0 {name=p432 sig_type=std_logic lab=enb}
C {dac.sym} 5300 -1900 0 0 {name=x73}
C {lab_wire.sym} 5300 -1990 0 0 {name=p433 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5300 -1800 0 1 {name=p434 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5460 -1900 0 1 {name=p435 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5140 -1920 0 0 {name=p436 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5230 -1800 0 0 {name=p437 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5130 -1900 0 0 {name=p438 sig_type=std_logic lab=enb}
C {dac.sym} 5310 -1660 0 0 {name=x74}
C {lab_wire.sym} 5310 -1750 0 0 {name=p439 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5310 -1560 0 1 {name=p440 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5470 -1660 0 1 {name=p441 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5150 -1680 0 0 {name=p442 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5240 -1560 0 0 {name=p443 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5140 -1660 0 0 {name=p444 sig_type=std_logic lab=enb}
C {dac.sym} 5310 -1410 0 0 {name=x75}
C {lab_wire.sym} 5310 -1500 0 0 {name=p445 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5310 -1310 0 1 {name=p446 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5470 -1410 0 1 {name=p447 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5150 -1430 0 0 {name=p448 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5240 -1310 0 0 {name=p449 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5140 -1410 0 0 {name=p450 sig_type=std_logic lab=enb}
C {dac.sym} 5320 -1170 0 0 {name=x76}
C {lab_wire.sym} 5320 -1260 0 0 {name=p451 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5320 -1070 0 1 {name=p452 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5480 -1170 0 1 {name=p453 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5160 -1190 0 0 {name=p454 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5250 -1070 0 0 {name=p455 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5150 -1170 0 0 {name=p456 sig_type=std_logic lab=enb}
C {dac.sym} 5320 -930 0 0 {name=x77}
C {lab_wire.sym} 5320 -1020 0 0 {name=p457 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5320 -830 0 1 {name=p458 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5480 -930 0 1 {name=p459 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5160 -950 0 0 {name=p460 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5250 -830 0 0 {name=p461 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5150 -930 0 0 {name=p462 sig_type=std_logic lab=enb}
C {dac.sym} 5330 -690 0 0 {name=x78}
C {lab_wire.sym} 5330 -780 0 0 {name=p463 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5330 -590 0 1 {name=p464 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5490 -690 0 1 {name=p465 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5170 -710 0 0 {name=p466 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5260 -590 0 0 {name=p467 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5160 -690 0 0 {name=p468 sig_type=std_logic lab=enb}
C {dac.sym} 5330 -440 0 0 {name=x79}
C {lab_wire.sym} 5330 -530 0 0 {name=p469 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5330 -340 0 1 {name=p470 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5490 -440 0 1 {name=p471 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5170 -460 0 0 {name=p472 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5260 -340 0 0 {name=p473 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5160 -440 0 0 {name=p474 sig_type=std_logic lab=enb}
C {dac.sym} 5340 -200 0 0 {name=x80}
C {lab_wire.sym} 5340 -290 0 0 {name=p475 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5340 -100 0 1 {name=p476 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5500 -200 0 1 {name=p477 sig_type=std_logic lab=DATA12}
C {lab_wire.sym} 5180 -220 0 0 {name=p478 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5270 -100 0 0 {name=p479 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5170 -200 0 0 {name=p480 sig_type=std_logic lab=enb}
C {dac.sym} 5930 -1900 0 0 {name=x81}
C {lab_wire.sym} 5930 -1990 0 0 {name=p481 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5930 -1800 0 1 {name=p482 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6090 -1900 0 1 {name=p483 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5770 -1920 0 0 {name=p484 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5860 -1800 0 0 {name=p485 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5760 -1900 0 0 {name=p486 sig_type=std_logic lab=enb}
C {dac.sym} 5930 -1660 0 0 {name=x82}
C {lab_wire.sym} 5930 -1750 0 0 {name=p487 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5930 -1560 0 1 {name=p488 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6090 -1660 0 1 {name=p489 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5770 -1680 0 0 {name=p490 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5860 -1560 0 0 {name=p491 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5760 -1660 0 0 {name=p492 sig_type=std_logic lab=enb}
C {dac.sym} 5940 -1420 0 0 {name=x83}
C {lab_wire.sym} 5940 -1510 0 0 {name=p493 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5940 -1320 0 1 {name=p494 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6100 -1420 0 1 {name=p495 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5780 -1440 0 0 {name=p496 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5870 -1320 0 0 {name=p497 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5770 -1420 0 0 {name=p498 sig_type=std_logic lab=enb}
C {dac.sym} 5940 -1180 0 0 {name=x84}
C {lab_wire.sym} 5940 -1270 0 0 {name=p499 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5940 -1080 0 1 {name=p500 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6100 -1180 0 1 {name=p501 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5780 -1200 0 0 {name=p502 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5870 -1080 0 0 {name=p503 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5770 -1180 0 0 {name=p504 sig_type=std_logic lab=enb}
C {dac.sym} 5940 -930 0 0 {name=x85}
C {lab_wire.sym} 5940 -1020 0 0 {name=p505 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5940 -830 0 1 {name=p506 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6100 -930 0 1 {name=p507 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5780 -950 0 0 {name=p508 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5870 -830 0 0 {name=p509 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5770 -930 0 0 {name=p510 sig_type=std_logic lab=enb}
C {dac.sym} 5940 -690 0 0 {name=x86}
C {lab_wire.sym} 5940 -780 0 0 {name=p511 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5940 -590 0 1 {name=p512 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6100 -690 0 1 {name=p513 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5780 -710 0 0 {name=p514 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5870 -590 0 0 {name=p515 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5770 -690 0 0 {name=p516 sig_type=std_logic lab=enb}
C {dac.sym} 5950 -450 0 0 {name=x87}
C {lab_wire.sym} 5950 -540 0 0 {name=p517 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5950 -350 0 1 {name=p518 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6110 -450 0 1 {name=p519 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5790 -470 0 0 {name=p520 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5880 -350 0 0 {name=p521 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5780 -450 0 0 {name=p522 sig_type=std_logic lab=enb}
C {dac.sym} 5950 -210 0 0 {name=x88}
C {lab_wire.sym} 5950 -300 0 0 {name=p523 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5950 -110 0 1 {name=p524 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6110 -210 0 1 {name=p525 sig_type=std_logic lab=DATA13}
C {lab_wire.sym} 5790 -230 0 0 {name=p526 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5880 -110 0 0 {name=p527 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5780 -210 0 0 {name=p528 sig_type=std_logic lab=enb}
C {dac.sym} 6570 -1890 0 0 {name=x89}
C {lab_wire.sym} 6570 -1980 0 0 {name=p529 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6570 -1790 0 1 {name=p530 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6730 -1890 0 1 {name=p531 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6410 -1910 0 0 {name=p532 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6500 -1790 0 0 {name=p533 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6400 -1890 0 0 {name=p534 sig_type=std_logic lab=enb}
C {dac.sym} 6570 -1660 0 0 {name=x90}
C {lab_wire.sym} 6570 -1750 0 0 {name=p535 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6570 -1560 0 1 {name=p536 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6730 -1660 0 1 {name=p537 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6410 -1680 0 0 {name=p538 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6500 -1560 0 0 {name=p539 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6400 -1660 0 0 {name=p540 sig_type=std_logic lab=enb}
C {dac.sym} 6580 -1420 0 0 {name=x91}
C {lab_wire.sym} 6580 -1510 0 0 {name=p541 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6580 -1320 0 1 {name=p542 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6740 -1420 0 1 {name=p543 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6420 -1440 0 0 {name=p544 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6510 -1320 0 0 {name=p545 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6410 -1420 0 0 {name=p546 sig_type=std_logic lab=enb}
C {dac.sym} 6580 -1190 0 0 {name=x92}
C {lab_wire.sym} 6580 -1280 0 0 {name=p547 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6580 -1090 0 1 {name=p548 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6740 -1190 0 1 {name=p549 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6420 -1210 0 0 {name=p550 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6510 -1090 0 0 {name=p551 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6410 -1190 0 0 {name=p552 sig_type=std_logic lab=enb}
C {dac.sym} 6590 -950 0 0 {name=x93}
C {lab_wire.sym} 6590 -1040 0 0 {name=p553 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6590 -850 0 1 {name=p554 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6750 -950 0 1 {name=p555 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6430 -970 0 0 {name=p556 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6520 -850 0 0 {name=p557 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6420 -950 0 0 {name=p558 sig_type=std_logic lab=enb}
C {dac.sym} 6590 -720 0 0 {name=x94}
C {lab_wire.sym} 6590 -810 0 0 {name=p559 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6590 -620 0 1 {name=p560 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6750 -720 0 1 {name=p561 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6430 -740 0 0 {name=p562 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6520 -620 0 0 {name=p563 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6420 -720 0 0 {name=p564 sig_type=std_logic lab=enb}
C {dac.sym} 6600 -480 0 0 {name=x95}
C {lab_wire.sym} 6600 -570 0 0 {name=p565 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6600 -380 0 1 {name=p566 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6760 -480 0 1 {name=p567 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6440 -500 0 0 {name=p568 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6530 -380 0 0 {name=p569 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6430 -480 0 0 {name=p570 sig_type=std_logic lab=enb}
C {dac.sym} 6600 -250 0 0 {name=x96}
C {lab_wire.sym} 6600 -340 0 0 {name=p571 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 6600 -150 0 1 {name=p572 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 6760 -250 0 1 {name=p573 sig_type=std_logic lab=DATA14}
C {lab_wire.sym} 6440 -270 0 0 {name=p574 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 6530 -150 0 0 {name=p575 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 6430 -250 0 0 {name=p576 sig_type=std_logic lab=enb}
C {dac.sym} 7180 -1890 0 0 {name=x97}
C {lab_wire.sym} 7180 -1980 0 0 {name=p577 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7180 -1790 0 1 {name=p578 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7340 -1890 0 1 {name=p579 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7020 -1910 0 0 {name=p580 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7110 -1790 0 0 {name=p581 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7010 -1890 0 0 {name=p582 sig_type=std_logic lab=enb}
C {dac.sym} 7180 -1660 0 0 {name=x98}
C {lab_wire.sym} 7180 -1750 0 0 {name=p583 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7180 -1560 0 1 {name=p584 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7340 -1660 0 1 {name=p585 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7020 -1680 0 0 {name=p586 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7110 -1560 0 0 {name=p587 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7010 -1660 0 0 {name=p588 sig_type=std_logic lab=enb}
C {dac.sym} 7180 -1410 0 0 {name=x99}
C {lab_wire.sym} 7180 -1500 0 0 {name=p589 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7180 -1310 0 1 {name=p590 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7340 -1410 0 1 {name=p591 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7020 -1430 0 0 {name=p592 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7110 -1310 0 0 {name=p593 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7010 -1410 0 0 {name=p594 sig_type=std_logic lab=enb}
C {dac.sym} 7180 -1180 0 0 {name=x100}
C {lab_wire.sym} 7180 -1270 0 0 {name=p595 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7180 -1080 0 1 {name=p596 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7340 -1180 0 1 {name=p597 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7020 -1200 0 0 {name=p598 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7110 -1080 0 0 {name=p599 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7010 -1180 0 0 {name=p600 sig_type=std_logic lab=enb}
C {dac.sym} 7190 -930 0 0 {name=x101}
C {lab_wire.sym} 7190 -1020 0 0 {name=p601 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7190 -830 0 1 {name=p602 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7350 -930 0 1 {name=p603 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7030 -950 0 0 {name=p604 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7120 -830 0 0 {name=p605 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7020 -930 0 0 {name=p606 sig_type=std_logic lab=enb}
C {dac.sym} 7190 -700 0 0 {name=x102}
C {lab_wire.sym} 7190 -790 0 0 {name=p607 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7190 -600 0 1 {name=p608 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7350 -700 0 1 {name=p609 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7030 -720 0 0 {name=p610 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7120 -600 0 0 {name=p611 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7020 -700 0 0 {name=p612 sig_type=std_logic lab=enb}
C {dac.sym} 7190 -450 0 0 {name=x103}
C {lab_wire.sym} 7190 -540 0 0 {name=p613 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7190 -350 0 1 {name=p614 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7350 -450 0 1 {name=p615 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7030 -470 0 0 {name=p616 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7120 -350 0 0 {name=p617 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7020 -450 0 0 {name=p618 sig_type=std_logic lab=enb}
C {dac.sym} 7190 -220 0 0 {name=x104}
C {lab_wire.sym} 7190 -310 0 0 {name=p619 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7190 -120 0 1 {name=p620 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7350 -220 0 1 {name=p621 sig_type=std_logic lab=DATA15}
C {lab_wire.sym} 7030 -240 0 0 {name=p622 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7120 -120 0 0 {name=p623 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7020 -220 0 0 {name=p624 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -1880 0 0 {name=x105}
C {lab_wire.sym} 7710 -1970 0 0 {name=p625 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -1780 0 1 {name=p626 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -1880 0 1 {name=p627 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -1900 0 0 {name=p628 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -1780 0 0 {name=p629 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -1880 0 0 {name=p630 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -1640 0 0 {name=x106}
C {lab_wire.sym} 7710 -1730 0 0 {name=p631 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -1540 0 1 {name=p632 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -1640 0 1 {name=p633 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -1660 0 0 {name=p634 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -1540 0 0 {name=p635 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -1640 0 0 {name=p636 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -1400 0 0 {name=x107}
C {lab_wire.sym} 7710 -1490 0 0 {name=p637 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -1300 0 1 {name=p638 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -1400 0 1 {name=p639 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -1420 0 0 {name=p640 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -1300 0 0 {name=p641 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -1400 0 0 {name=p642 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -1160 0 0 {name=x108}
C {lab_wire.sym} 7710 -1250 0 0 {name=p643 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -1060 0 1 {name=p644 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -1160 0 1 {name=p645 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -1180 0 0 {name=p646 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -1060 0 0 {name=p647 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -1160 0 0 {name=p648 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -920 0 0 {name=x109}
C {lab_wire.sym} 7710 -1010 0 0 {name=p649 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -820 0 1 {name=p650 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -920 0 1 {name=p651 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -940 0 0 {name=p652 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -820 0 0 {name=p653 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -920 0 0 {name=p654 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -680 0 0 {name=x110}
C {lab_wire.sym} 7710 -770 0 0 {name=p655 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -580 0 1 {name=p656 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -680 0 1 {name=p657 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -700 0 0 {name=p658 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -580 0 0 {name=p659 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -680 0 0 {name=p660 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -440 0 0 {name=x111}
C {lab_wire.sym} 7710 -530 0 0 {name=p661 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -340 0 1 {name=p662 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -440 0 1 {name=p663 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -460 0 0 {name=p664 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -340 0 0 {name=p665 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -440 0 0 {name=p666 sig_type=std_logic lab=enb}
C {dac.sym} 7710 -200 0 0 {name=x112}
C {lab_wire.sym} 7710 -290 0 0 {name=p667 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 7710 -100 0 1 {name=p668 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 7870 -200 0 1 {name=p669 sig_type=std_logic lab=DATA16}
C {lab_wire.sym} 7550 -220 0 0 {name=p670 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 7640 -100 0 0 {name=p671 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 7540 -200 0 0 {name=p672 sig_type=std_logic lab=enb}
C {dac.sym} 8300 -1880 0 0 {name=x113}
C {lab_wire.sym} 8300 -1970 0 0 {name=p673 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8300 -1780 0 1 {name=p674 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8460 -1880 0 1 {name=p675 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8140 -1900 0 0 {name=p676 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8230 -1780 0 0 {name=p677 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8130 -1880 0 0 {name=p678 sig_type=std_logic lab=enb}
C {dac.sym} 8300 -1640 0 0 {name=x114}
C {lab_wire.sym} 8300 -1730 0 0 {name=p679 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8300 -1540 0 1 {name=p680 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8460 -1640 0 1 {name=p681 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8140 -1660 0 0 {name=p682 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8230 -1540 0 0 {name=p683 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8130 -1640 0 0 {name=p684 sig_type=std_logic lab=enb}
C {dac.sym} 8310 -1380 0 0 {name=x115}
C {lab_wire.sym} 8310 -1470 0 0 {name=p685 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8310 -1280 0 1 {name=p686 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8470 -1380 0 1 {name=p687 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8150 -1400 0 0 {name=p688 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8240 -1280 0 0 {name=p689 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8140 -1380 0 0 {name=p690 sig_type=std_logic lab=enb}
C {dac.sym} 8310 -1140 0 0 {name=x116}
C {lab_wire.sym} 8310 -1230 0 0 {name=p691 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8310 -1040 0 1 {name=p692 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8470 -1140 0 1 {name=p693 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8150 -1160 0 0 {name=p694 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8240 -1040 0 0 {name=p695 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8140 -1140 0 0 {name=p696 sig_type=std_logic lab=enb}
C {dac.sym} 8320 -900 0 0 {name=x117}
C {lab_wire.sym} 8320 -990 0 0 {name=p697 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8320 -800 0 1 {name=p698 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8480 -900 0 1 {name=p699 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8160 -920 0 0 {name=p700 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8250 -800 0 0 {name=p701 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8150 -900 0 0 {name=p702 sig_type=std_logic lab=enb}
C {dac.sym} 8320 -660 0 0 {name=x118}
C {lab_wire.sym} 8320 -750 0 0 {name=p703 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8320 -560 0 1 {name=p704 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8480 -660 0 1 {name=p705 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8160 -680 0 0 {name=p706 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8250 -560 0 0 {name=p707 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8150 -660 0 0 {name=p708 sig_type=std_logic lab=enb}
C {dac.sym} 8330 -400 0 0 {name=x119}
C {lab_wire.sym} 8330 -490 0 0 {name=p709 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8330 -300 0 1 {name=p710 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8490 -400 0 1 {name=p711 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8170 -420 0 0 {name=p712 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8260 -300 0 0 {name=p713 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8160 -400 0 0 {name=p714 sig_type=std_logic lab=enb}
C {dac.sym} 8330 -160 0 0 {name=x120}
C {lab_wire.sym} 8330 -250 0 0 {name=p715 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 8330 -60 0 1 {name=p716 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 8490 -160 0 1 {name=p717 sig_type=std_logic lab=DATA17}
C {lab_wire.sym} 8170 -180 0 0 {name=p718 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 8260 -60 0 0 {name=p719 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 8160 -160 0 0 {name=p720 sig_type=std_logic lab=enb}
C {iopin.sym} 340 -2410 2 0 {name=p721 lab=AVDD}
C {iopin.sym} 340 -2380 2 0 {name=p722 lab=AVSS}
C {iopin.sym} 340 -2350 2 0 {name=p723 lab=VBIAS}
C {iopin.sym} 340 -2320 2 0 {name=p724 lab=en_bb}
C {iopin.sym} 530 -2380 2 0 {name=p725 lab=DATA4}
C {iopin.sym} 340 -2290 2 0 {name=p726 lab=ISUM}
C {iopin.sym} 530 -2410 2 0 {name=p727 lab=DATA3}
C {iopin.sym} 530 -2350 2 0 {name=p728 lab=DATA5}
C {iopin.sym} 530 -2290 2 0 {name=p729 lab=DATA7}
C {iopin.sym} 530 -2320 2 0 {name=p730 lab=DATA6}
C {iopin.sym} 690 -2410 2 0 {name=p731 lab=DATA8}
C {iopin.sym} 690 -2380 2 0 {name=p732 lab=DATA9}
C {iopin.sym} 690 -2350 2 0 {name=p733 lab=DATA10}
C {iopin.sym} 690 -2290 2 0 {name=p734 lab=DATA12}
C {iopin.sym} 690 -2320 2 0 {name=p735 lab=DATA11}
C {iopin.sym} 850 -2410 2 0 {name=p736 lab=DATA13}
C {iopin.sym} 850 -2380 2 0 {name=p737 lab=DATA14}
C {iopin.sym} 850 -2350 2 0 {name=p738 lab=DATA15}
C {iopin.sym} 850 -2320 2 0 {name=p739 lab=DATA16}
C {iopin.sym} 850 -2290 2 0 {name=p740 lab=DATA17}
