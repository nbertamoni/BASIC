v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} 220 -300 2 0 {name=p48 lab=vin}
C {iopin.sym} 220 -270 2 0 {name=p1 lab=gnd}
C {iopin.sym} 220 -200 2 0 {name=p2 lab=out0}
C {iopin.sym} 220 -180 2 0 {name=p4 lab=out1
}
C {iopin.sym} 220 -160 2 0 {name=p5 lab=out2}
C {iopin.sym} 220 -140 2 0 {name=p6 lab=out3}
C {iopin.sym} 220 -120 2 0 {name=p7 lab=out4}
C {iopin.sym} 220 -100 2 0 {name=p8 lab=out5}
C {iopin.sym} 220 -80 2 0 {name=p9 lab=out6}
C {iopin.sym} 220 -60 2 0 {name=p10 lab=out7}
C {iopin.sym} 220 -40 2 0 {name=p11 lab=out8}
C {iopin.sym} 220 -20 2 0 {name=p12 lab=out9}
C {iopin.sym} 340 -200 2 0 {name=p13 lab=out10}
C {iopin.sym} 340 -180 2 0 {name=p14 lab=out11}
C {iopin.sym} 340 -160 2 0 {name=p15 lab=out12}
C {iopin.sym} 340 -140 2 0 {name=p16 lab=out13}
C {iopin.sym} 340 -120 2 0 {name=p17 lab=out14}
C {iopin.sym} 340 -100 2 0 {name=p18 lab=out15}
C {iopin.sym} 340 -80 2 0 {name=p19 lab=out16}
C {iopin.sym} 340 -60 2 0 {name=p20 lab=out17}
