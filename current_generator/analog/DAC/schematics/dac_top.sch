v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 790 -850 790 -810 {lab=AVDD}
N 920 -1240 920 -1200 {lab=AVDD}
N 790 -630 790 -590 {lab=AVSS}
N 600 -740 640 -740 {lab=SEL}
N 600 -720 640 -720 {lab=en_bb}
N 600 -700 640 -700 {lab=en_b}
N 730 -1120 770 -1120 {lab=en_bb}
N 1070 -1120 1110 -1120 {lab=AVSS}
N 920 -1040 920 -1000 {lab=AVSS}
N 1450 -280 1490 -280 {lab=en}
N 1570 -280 1640 -280 {lab=en_b}
N 1720 -280 1760 -280 {lab=en_bb}
N 680 -1140 770 -1140 {lab=VBIAS}
N 680 -1140 680 -1000 {lab=VBIAS}
N 680 -1000 850 -1000 {lab=VBIAS}
N 850 -1040 850 -1000 {lab=VBIAS}
N 1100 -370 1160 -370 {lab=sign}
N 1100 -350 1160 -350 {lab=sign_b}
N 950 -280 950 -250 {lab=AVSS}
N 950 -480 950 -440 {lab=AVDD}
N 750 -370 800 -370 {lab=i_sign}
N 750 -350 800 -350 {lab=i_signb}
N 510 -810 730 -810 {lab=IBIAS}
N 510 -970 510 -810 {lab=IBIAS}
N 850 -1000 850 -810 {lab=VBIAS}
N 1540 -550 1600 -550 {lab=sign}
N 1540 -530 1600 -530 {lab=sign_b}
N 1900 -560 1940 -560 {lab=CC_P}
N 1900 -540 1940 -540 {lab=CC_N}
N 1750 -470 1750 -440 {lab=AVSS}
N 1560 -570 1600 -570 {lab=ISUM}
N 1560 -590 1560 -570 {lab=ISUM}
N 1460 -590 1560 -590 {lab=ISUM}
N 940 -1630 990 -1630 {lab=AVDD}
N 940 -1600 990 -1600 {lab=AVSS}
N 940 -1540 990 -1540 {lab=DATA[17:0]}
N 940 -1570 990 -1570 {lab=en}
N 940 -1510 990 -1510 {lab=IBIAS}
N 940 -1480 990 -1480 {lab=SEL}
N 940 -1450 990 -1450 {lab=i_sign}
N 940 -1370 990 -1370 {lab=CC_P}
N 940 -1340 990 -1340 {lab=CC_N}
N 680 -1200 680 -1140 {lab=VBIAS}
N 680 -1300 680 -1260 {lab=AVDD}
N 2670 -1170 2670 -1130 {lab=AVDD}
N 2480 -1050 2520 -1050 {lab=en_bb}
N 2820 -1050 2870 -1050 {lab=DATA[0]}
N 2670 -970 2670 -930 {lab=AVSS}
N 2430 -1070 2520 -1070 {lab=VBIAS}
N 2600 -970 2600 -930 {lab=ISUM}
N 2670 -900 2670 -860 {lab=AVDD}
N 2480 -780 2520 -780 {lab=en_bb}
N 2820 -780 2870 -780 {lab=DATA[1]}
N 2670 -700 2670 -660 {lab=AVSS}
N 2430 -800 2520 -800 {lab=VBIAS}
N 2600 -700 2600 -660 {lab=ISUM}
N 2670 -630 2670 -590 {lab=AVDD}
N 2480 -510 2520 -510 {lab=en_bb}
N 2820 -510 2870 -510 {lab=DATA[2]}
N 2670 -430 2670 -390 {lab=AVSS}
N 2430 -530 2520 -530 {lab=VBIAS}
N 2600 -430 2600 -390 {lab=ISUM}
N 3370 -1190 3370 -1150 {lab=AVDD}
N 3180 -1070 3220 -1070 {lab=en_bb}
N 3520 -1070 3570 -1070 {lab=DATA[3]}
N 3370 -990 3370 -950 {lab=AVSS}
N 3130 -1090 3220 -1090 {lab=VBIAS}
N 3300 -990 3300 -950 {lab=ISUM}
N 3370 -910 3370 -870 {lab=AVDD}
N 3180 -790 3220 -790 {lab=en_bb}
N 3520 -790 3570 -790 {lab=DATA[4]}
N 3370 -710 3370 -670 {lab=AVSS}
N 3130 -810 3220 -810 {lab=VBIAS}
N 3300 -710 3300 -670 {lab=ISUM}
N 3370 -630 3370 -590 {lab=AVDD}
N 3180 -510 3220 -510 {lab=en_bb}
N 3520 -510 3570 -510 {lab=DATA[5]}
N 3370 -430 3370 -390 {lab=AVSS}
N 3130 -530 3220 -530 {lab=VBIAS}
N 3300 -430 3300 -390 {lab=ISUM}
N 3370 -350 3370 -310 {lab=AVDD}
N 3180 -230 3220 -230 {lab=en_bb}
N 3520 -230 3570 -230 {lab=DATA[6]}
N 3370 -150 3370 -110 {lab=AVSS}
N 3130 -250 3220 -250 {lab=VBIAS}
N 3300 -150 3300 -110 {lab=ISUM}
N 4100 -1160 4100 -1120 {lab=AVDD}
N 3910 -1040 3950 -1040 {lab=en_bb}
N 4250 -1040 4300 -1040 {lab=DATA[7]}
N 4100 -960 4100 -920 {lab=AVSS}
N 3860 -1060 3950 -1060 {lab=VBIAS}
N 4030 -960 4030 -920 {lab=ISUM}
N 4110 -870 4110 -830 {lab=AVDD}
N 3920 -750 3960 -750 {lab=en_bb}
N 4260 -750 4310 -750 {lab=DATA[8]}
N 4110 -670 4110 -630 {lab=AVSS}
N 3870 -770 3960 -770 {lab=VBIAS}
N 4040 -670 4040 -630 {lab=ISUM}
N 4110 -590 4110 -550 {lab=AVDD}
N 3920 -470 3960 -470 {lab=en_bb}
N 4260 -470 4310 -470 {lab=DATA[9]}
N 4110 -390 4110 -350 {lab=AVSS}
N 3870 -490 3960 -490 {lab=VBIAS}
N 4040 -390 4040 -350 {lab=ISUM}
N 4110 -320 4110 -280 {lab=AVDD}
N 3920 -200 3960 -200 {lab=en_bb}
N 4260 -200 4310 -200 {lab=DATA[10]}
N 4110 -120 4110 -80 {lab=AVSS}
N 3870 -220 3960 -220 {lab=VBIAS}
N 4040 -120 4040 -80 {lab=ISUM}
N 4700 -1180 4700 -1140 {lab=AVDD}
N 4510 -1060 4550 -1060 {lab=en_bb}
N 4850 -1060 4900 -1060 {lab=DATA[11]}
N 4700 -980 4700 -940 {lab=AVSS}
N 4460 -1080 4550 -1080 {lab=VBIAS}
N 4630 -980 4630 -940 {lab=ISUM}
N 4720 -870 4720 -830 {lab=AVDD}
N 4530 -750 4570 -750 {lab=en_bb}
N 4870 -750 4920 -750 {lab=DATA[12]}
N 4720 -670 4720 -630 {lab=AVSS}
N 4480 -770 4570 -770 {lab=VBIAS}
N 4650 -670 4650 -630 {lab=ISUM}
N 4720 -580 4720 -540 {lab=AVDD}
N 4530 -460 4570 -460 {lab=en_bb}
N 4870 -460 4920 -460 {lab=DATA[13]}
N 4720 -380 4720 -340 {lab=AVSS}
N 4480 -480 4570 -480 {lab=VBIAS}
N 4650 -380 4650 -340 {lab=ISUM}
N 4720 -300 4720 -260 {lab=AVDD}
N 4530 -180 4570 -180 {lab=en_bb}
N 4870 -180 4920 -180 {lab=DATA[14]}
N 4720 -100 4720 -60 {lab=AVSS}
N 4480 -200 4570 -200 {lab=VBIAS}
N 4650 -100 4650 -60 {lab=ISUM}
N 5390 -1160 5390 -1120 {lab=AVDD}
N 5200 -1040 5240 -1040 {lab=en_bb}
N 5540 -1040 5590 -1040 {lab=DATA[15]}
N 5390 -960 5390 -920 {lab=AVSS}
N 5150 -1060 5240 -1060 {lab=VBIAS}
N 5320 -960 5320 -920 {lab=ISUM}
N 5380 -880 5380 -840 {lab=AVDD}
N 5190 -760 5230 -760 {lab=en_bb}
N 5530 -760 5580 -760 {lab=DATA[16]}
N 5380 -680 5380 -640 {lab=AVSS}
N 5310 -680 5310 -640 {lab=ISUM}
N 5380 -580 5380 -540 {lab=AVDD}
N 5190 -460 5230 -460 {lab=en_bb}
N 5530 -460 5580 -460 {lab=DATA[17]}
N 5380 -380 5380 -340 {lab=AVSS}
N 5310 -380 5310 -340 {lab=ISUM}
N 940 -1410 990 -1410 {lab=i_signb}
N 1680 -250 1680 -220 {lab=AVSS}
N 1530 -250 1530 -220 {lab=AVSS}
N 1530 -350 1530 -310 {lab=AVDD}
N 1680 -350 1680 -310 {lab=AVDD}
N 5140 -780 5230 -780 {lab=VBIAS}
N 5140 -480 5230 -480 {lab=VBIAS}
C {current_mirror.sym} 790 -720 0 0 {name=x8}
C {lab_wire.sym} 790 -830 0 0 {name=p12 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 770 -1000 0 0 {name=p13 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 620 -740 0 0 {name=p14 sig_type=std_logic lab=SEL}
C {lab_wire.sym} 630 -720 0 0 {name=p15 sig_type=std_logic lab=en_bb}
C {lab_wire.sym} 630 -700 0 0 {name=p16 sig_type=std_logic lab=en_b}
C {lab_wire.sym} 790 -600 0 0 {name=p17 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 920 -1010 0 0 {name=p18 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 920 -1230 0 0 {name=p19 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 760 -1120 0 0 {name=p21 sig_type=std_logic lab=en_bb}
C {lab_wire.sym} 1090 -1120 0 1 {name=p28 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1460 -280 0 0 {name=p44 sig_type=std_logic lab=en}
C {lab_wire.sym} 1620 -280 0 0 {name=p45 sig_type=std_logic lab=en_b}
C {lab_wire.sym} 510 -950 0 0 {name=p24 sig_type=std_logic lab=IBIAS}
C {lab_wire.sym} 1750 -280 0 1 {name=p50 sig_type=std_logic lab=en_bb}
C {non_overlap.sym} 950 -360 0 0 {name=x6}
C {lab_wire.sym} 1150 -370 0 1 {name=p30 sig_type=std_logic lab=sign}
C {lab_wire.sym} 1150 -350 0 1 {name=p31 sig_type=std_logic lab=sign_b}
C {lab_wire.sym} 950 -260 0 0 {name=p32 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 950 -460 0 0 {name=p33 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 770 -350 0 0 {name=p34 sig_type=std_logic lab=i_signb}
C {lab_wire.sym} 770 -370 0 0 {name=p35 sig_type=std_logic lab=i_sign}
C {lab_wire.sym} 1930 -560 0 1 {name=p68 sig_type=std_logic lab=CC_P}
C {dsw.sym} 1750 -550 0 0 {name=x9}
C {lab_wire.sym} 1930 -540 0 1 {name=p107 sig_type=std_logic lab=CC_N}
C {lab_wire.sym} 1750 -450 0 0 {name=p108 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1550 -550 0 0 {name=p109 sig_type=std_logic lab=sign}
C {lab_wire.sym} 1550 -530 0 0 {name=p110 sig_type=std_logic lab=sign_b}
C {lab_wire.sym} 1510 -590 0 0 {name=p113 sig_type=std_logic lab=ISUM}
C {dac.sym} 920 -1120 0 0 {name=x1[7:0]}
C {iopin.sym} 940 -1630 2 0 {name=p721 lab=AVDD}
C {iopin.sym} 940 -1600 2 0 {name=p722 lab=AVSS}
C {iopin.sym} 940 -1570 2 0 {name=p724 lab=en}
C {iopin.sym} 940 -1540 2 0 {name=p727 lab=DATA[17:0]}
C {iopin.sym} 940 -1510 2 0 {name=p1 lab=IBIAS}
C {iopin.sym} 940 -1480 2 0 {name=p2 lab=SEL}
C {iopin.sym} 940 -1450 2 0 {name=p3 lab=i_sign}
C {iopin.sym} 940 -1370 2 0 {name=p6 lab=CC_P}
C {iopin.sym} 940 -1340 2 0 {name=p7 lab=CC_N}
C {sg13g2_pr/cap_cmim.sym} 680 -1230 0 0 {name=C1
model=cap_cmim
w=18e-6
l=18e-6
m=80
spiceprefix=X}
C {lab_wire.sym} 680 -1290 0 0 {name=p25 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2670 -1160 0 0 {name=p9 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2510 -1050 0 0 {name=p11 sig_type=std_logic lab=en_bb}
C {dac.sym} 2670 -1050 0 0 {name=xb0}
C {lab_wire.sym} 2510 -1070 0 0 {name=p36 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2670 -940 0 1 {name=p37 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2600 -950 0 0 {name=p38 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2670 -890 0 0 {name=p27 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2510 -780 0 0 {name=p40 sig_type=std_logic lab=en_bb}
C {dac.sym} 2670 -780 0 0 {name=xb1[1:0]}
C {lab_wire.sym} 2510 -800 0 0 {name=p41 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2670 -670 0 1 {name=p42 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2600 -680 0 0 {name=p43 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 2670 -620 0 0 {name=p47 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2510 -510 0 0 {name=p48 sig_type=std_logic lab=en_bb}
C {dac.sym} 2670 -510 0 0 {name=xb2[3:0]}
C {lab_wire.sym} 2510 -530 0 0 {name=p49 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 2670 -400 0 1 {name=p55 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2600 -410 0 0 {name=p56 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3370 -1180 0 0 {name=p61 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3210 -1070 0 0 {name=p62 sig_type=std_logic lab=en_bb}
C {dac.sym} 3370 -1070 0 0 {name=xb3[7:0]}
C {lab_wire.sym} 3210 -1090 0 0 {name=p63 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3370 -960 0 1 {name=p64 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3300 -970 0 0 {name=p65 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3370 -900 0 0 {name=p70 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3210 -790 0 0 {name=p71 sig_type=std_logic lab=en_bb}
C {dac.sym} 3370 -790 0 0 {name=xb4[7:0]}
C {lab_wire.sym} 3210 -810 0 0 {name=p72 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3370 -680 0 1 {name=p73 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3300 -690 0 0 {name=p74 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3370 -620 0 0 {name=p76 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3210 -510 0 0 {name=p77 sig_type=std_logic lab=en_bb}
C {dac.sym} 3370 -510 0 0 {name=xb5[7:0]}
C {lab_wire.sym} 3210 -530 0 0 {name=p78 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3370 -400 0 1 {name=p79 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3300 -410 0 0 {name=p80 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3370 -340 0 0 {name=p82 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3210 -230 0 0 {name=p83 sig_type=std_logic lab=en_bb}
C {dac.sym} 3370 -230 0 0 {name=xb6[7:0]}
C {lab_wire.sym} 3210 -250 0 0 {name=p84 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3370 -120 0 1 {name=p85 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3300 -130 0 0 {name=p86 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4100 -1150 0 0 {name=p88 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3940 -1040 0 0 {name=p89 sig_type=std_logic lab=en_bb}
C {dac.sym} 4100 -1040 0 0 {name=xb7[7:0]}
C {lab_wire.sym} 3940 -1060 0 0 {name=p90 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4100 -930 0 1 {name=p91 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4030 -940 0 0 {name=p92 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4110 -860 0 0 {name=p94 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3950 -750 0 0 {name=p95 sig_type=std_logic lab=en_bb}
C {dac.sym} 4110 -750 0 0 {name=xb8[7:0]}
C {lab_wire.sym} 3950 -770 0 0 {name=p96 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4110 -640 0 1 {name=p97 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4040 -650 0 0 {name=p98 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4110 -580 0 0 {name=p100 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3950 -470 0 0 {name=p101 sig_type=std_logic lab=en_bb}
C {dac.sym} 4110 -470 0 0 {name=xb9[7:0]}
C {lab_wire.sym} 3950 -490 0 0 {name=p102 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4110 -360 0 1 {name=p103 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4040 -370 0 0 {name=p104 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4110 -310 0 0 {name=p106 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3950 -200 0 0 {name=p111 sig_type=std_logic lab=en_bb}
C {dac.sym} 4110 -200 0 0 {name=xb10[7:0]}
C {lab_wire.sym} 3950 -220 0 0 {name=p112 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4110 -90 0 1 {name=p114 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4040 -100 0 0 {name=p115 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4700 -1160 0 0 {name=p117 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4540 -1060 0 0 {name=p118 sig_type=std_logic lab=en_bb}
C {dac.sym} 4700 -1060 0 0 {name=xb11[7:0]}
C {lab_wire.sym} 4540 -1080 0 0 {name=p119 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4700 -950 0 1 {name=p120 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4630 -960 0 0 {name=p121 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4720 -860 0 0 {name=p123 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4560 -750 0 0 {name=p124 sig_type=std_logic lab=en_bb}
C {dac.sym} 4720 -750 0 0 {name=xb12[7:0]}
C {lab_wire.sym} 4560 -770 0 0 {name=p125 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4720 -640 0 1 {name=p126 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4650 -650 0 0 {name=p127 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4720 -570 0 0 {name=p129 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4560 -460 0 0 {name=p130 sig_type=std_logic lab=en_bb}
C {dac.sym} 4720 -460 0 0 {name=xb13[7:0]}
C {lab_wire.sym} 4560 -480 0 0 {name=p131 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4720 -350 0 1 {name=p132 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4650 -360 0 0 {name=p133 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4720 -290 0 0 {name=p135 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4560 -180 0 0 {name=p136 sig_type=std_logic lab=en_bb}
C {dac.sym} 4720 -180 0 0 {name=xb14[7:0]}
C {lab_wire.sym} 4560 -200 0 0 {name=p137 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4720 -70 0 1 {name=p138 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4650 -80 0 0 {name=p139 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5390 -1150 0 0 {name=p141 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5230 -1040 0 0 {name=p142 sig_type=std_logic lab=en_bb}
C {dac.sym} 5390 -1040 0 0 {name=xb15[7:0]}
C {lab_wire.sym} 5230 -1060 0 0 {name=p143 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5390 -930 0 1 {name=p144 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5320 -940 0 0 {name=p145 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5380 -870 0 0 {name=p147 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5220 -760 0 0 {name=p148 sig_type=std_logic lab=en_bb}
C {dac.sym} 5380 -760 0 0 {name=xb16[7:0]}
C {lab_wire.sym} 5220 -780 0 0 {name=p149 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5380 -650 0 1 {name=p150 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5310 -660 0 0 {name=p151 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5380 -570 0 0 {name=p153 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5220 -460 0 0 {name=p154 sig_type=std_logic lab=en_bb}
C {dac.sym} 5380 -460 0 0 {name=xb17[7:0]}
C {lab_wire.sym} 5220 -480 0 0 {name=p155 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5380 -350 0 1 {name=p156 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5310 -360 0 0 {name=p157 sig_type=std_logic lab=ISUM}
C {iopin.sym} 940 -1410 2 0 {name=p4 lab=i_signb}
C {inverter.sym} 1520 -280 0 0 {name=x1}
C {inverter.sym} 1670 -280 0 0 {name=x2}
C {lab_wire.sym} 1680 -230 0 0 {name=p5 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1530 -230 0 0 {name=p8 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1530 -330 0 0 {name=p10 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1680 -330 0 0 {name=p20 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2850 -1050 0 1 {name=p22 sig_type=std_logic lab=DATA[0]}
C {lab_wire.sym} 2850 -780 0 1 {name=p23 sig_type=std_logic lab=DATA[1]}
C {lab_wire.sym} 2850 -510 0 1 {name=p26 sig_type=std_logic lab=DATA[2]}
C {lab_wire.sym} 3550 -1070 0 1 {name=p29 sig_type=std_logic lab=DATA[3]}
C {lab_wire.sym} 3550 -790 0 1 {name=p39 sig_type=std_logic lab=DATA[4]}
C {lab_wire.sym} 3550 -510 0 1 {name=p46 sig_type=std_logic lab=DATA[5]}
C {lab_wire.sym} 3550 -230 0 1 {name=p51 sig_type=std_logic lab=DATA[6]}
C {lab_wire.sym} 4280 -1040 0 1 {name=p52 sig_type=std_logic lab=DATA[7]}
C {lab_wire.sym} 4280 -750 0 1 {name=p53 sig_type=std_logic lab=DATA[8]}
C {lab_wire.sym} 4290 -470 0 1 {name=p54 sig_type=std_logic lab=DATA[9]}
C {lab_wire.sym} 4290 -200 0 1 {name=p57 sig_type=std_logic lab=DATA[10]}
C {lab_wire.sym} 4880 -1060 0 1 {name=p58 sig_type=std_logic lab=DATA[11]}
C {lab_wire.sym} 4900 -750 0 1 {name=p59 sig_type=std_logic lab=DATA[12]}
C {lab_wire.sym} 4900 -460 0 1 {name=p60 sig_type=std_logic lab=DATA[13]}
C {lab_wire.sym} 4900 -180 0 1 {name=p66 sig_type=std_logic lab=DATA[14]}
C {lab_wire.sym} 5570 -1040 0 1 {name=p67 sig_type=std_logic lab=DATA[15]}
C {lab_wire.sym} 5560 -760 0 1 {name=p69 sig_type=std_logic lab=DATA[16]}
C {lab_wire.sym} 5560 -460 0 1 {name=p75 sig_type=std_logic lab=DATA[17]}
