v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 160 -1200 160 -1170 {lab=IREF}
N 160 -250 160 -200 {lab=AVSS}
N 390 -250 390 -200 {lab=AVSS}
N 160 -280 210 -280 {lab=AVSS}
N 390 -280 440 -280 {lab=AVSS}
N 90 -280 120 -280 {lab=EN}
N 320 -280 350 -280 {lab=EN}
N 710 -160 710 -110 {lab=AVSS}
N 960 -160 960 -110 {lab=AVSS}
N 960 -280 1010 -280 {lab=AVSS}
N 890 -280 920 -280 {lab=SEL_IOUT}
N 1220 -160 1220 -110 {lab=AVSS}
N 1470 -160 1470 -110 {lab=AVSS}
N 1730 -160 1730 -110 {lab=AVSS}
N 1980 -160 1980 -110 {lab=AVSS}
N 2240 -160 2240 -110 {lab=AVSS}
N 2490 -160 2490 -110 {lab=AVSS}
N 2740 -160 2740 -110 {lab=AVSS}
N 2990 -160 2990 -110 {lab=AVSS}
N 3250 -160 3250 -110 {lab=AVSS}
N 3500 -160 3500 -110 {lab=AVSS}
N 3760 -160 3760 -110 {lab=AVSS}
N 4020 -160 4020 -110 {lab=AVSS}
N 4270 -160 4270 -110 {lab=AVSS}
N 740 -1720 810 -1720 {lab=SELB}
N 890 -1720 970 -1720 {lab=SEL_IOUT}
N 560 -1740 620 -1740 {lab=EN}
N 560 -1700 620 -1700 {lab=SEL}
N 1170 -1690 1170 -1630 {lab=AVSS}
N 1170 -1720 1230 -1720 {lab=AVSS}
N 1170 -1820 1170 -1750 {lab=IREF}
N 1080 -1720 1130 -1720 {lab=ENB}
N 1230 -1720 1230 -1630 {lab=AVSS}
N 1170 -1630 1230 -1630 {lab=AVSS}
N 170 -1740 220 -1740 {lab=AVDD}
N 170 -1710 220 -1710 {lab=AVSS}
N 170 -1680 220 -1680 {lab=EN}
N 170 -1650 220 -1650 {lab=ENB}
N 170 -1620 220 -1620 {lab=SEL}
N 170 -1590 220 -1590 {lab=IREF}
N 170 -1560 220 -1560 {lab=IOUT}
N 960 -370 960 -310 {lab=#net1}
N 1220 -370 1220 -310 {lab=#net2}
N 1470 -370 1470 -310 {lab=#net3}
N 1730 -370 1730 -310 {lab=#net4}
N 1980 -370 1980 -310 {lab=#net5}
N 2240 -370 2240 -310 {lab=#net6}
N 2490 -370 2490 -310 {lab=#net7}
N 2740 -370 2740 -310 {lab=#net8}
N 2990 -370 2990 -310 {lab=#net9}
N 3250 -370 3250 -310 {lab=#net10}
N 3500 -370 3500 -310 {lab=#net11}
N 3760 -370 3760 -310 {lab=#net12}
N 4020 -370 4020 -310 {lab=#net13}
N 4270 -370 4270 -310 {lab=#net14}
N 160 -1270 160 -1200 {lab=IREF}
N 960 -190 1010 -190 {lab=AVSS}
N 890 -190 920 -190 {lab=SEL_IOUT}
N 960 -250 960 -220 {lab=#net15}
N 710 -280 760 -280 {lab=AVSS}
N 640 -280 670 -280 {lab=SEL_IOUT}
N 710 -190 760 -190 {lab=AVSS}
N 640 -190 670 -190 {lab=SEL_IOUT}
N 710 -250 710 -220 {lab=#net16}
N 1220 -280 1270 -280 {lab=AVSS}
N 1150 -280 1180 -280 {lab=SEL_IOUT}
N 1220 -190 1270 -190 {lab=AVSS}
N 1150 -190 1180 -190 {lab=SEL_IOUT}
N 1220 -250 1220 -220 {lab=#net17}
N 1470 -280 1520 -280 {lab=AVSS}
N 1400 -280 1430 -280 {lab=SEL_IOUT}
N 1470 -190 1520 -190 {lab=AVSS}
N 1400 -190 1430 -190 {lab=SEL_IOUT}
N 1470 -250 1470 -220 {lab=#net18}
N 1730 -280 1780 -280 {lab=AVSS}
N 1660 -280 1690 -280 {lab=SEL_IOUT}
N 1730 -190 1780 -190 {lab=AVSS}
N 1660 -190 1690 -190 {lab=SEL_IOUT}
N 1730 -250 1730 -220 {lab=#net19}
N 1980 -280 2030 -280 {lab=AVSS}
N 1910 -280 1940 -280 {lab=SEL_IOUT}
N 1980 -190 2030 -190 {lab=AVSS}
N 1910 -190 1940 -190 {lab=SEL_IOUT}
N 1980 -250 1980 -220 {lab=#net20}
N 2240 -280 2290 -280 {lab=AVSS}
N 2170 -280 2200 -280 {lab=SEL_IOUT}
N 2240 -190 2290 -190 {lab=AVSS}
N 2170 -190 2200 -190 {lab=SEL_IOUT}
N 2240 -250 2240 -220 {lab=#net21}
N 2490 -280 2540 -280 {lab=AVSS}
N 2420 -280 2450 -280 {lab=SEL_IOUT}
N 2490 -190 2540 -190 {lab=AVSS}
N 2420 -190 2450 -190 {lab=SEL_IOUT}
N 2490 -250 2490 -220 {lab=#net22}
N 2740 -280 2790 -280 {lab=AVSS}
N 2670 -280 2700 -280 {lab=SEL_IOUT}
N 2740 -190 2790 -190 {lab=AVSS}
N 2670 -190 2700 -190 {lab=SEL_IOUT}
N 2740 -250 2740 -220 {lab=#net23}
N 2990 -280 3040 -280 {lab=AVSS}
N 2920 -280 2950 -280 {lab=SEL_IOUT}
N 2990 -190 3040 -190 {lab=AVSS}
N 2920 -190 2950 -190 {lab=SEL_IOUT}
N 2990 -250 2990 -220 {lab=#net24}
N 3250 -280 3300 -280 {lab=AVSS}
N 3180 -280 3210 -280 {lab=SEL_IOUT}
N 3250 -190 3300 -190 {lab=AVSS}
N 3180 -190 3210 -190 {lab=SEL_IOUT}
N 3250 -250 3250 -220 {lab=#net25}
N 3500 -280 3550 -280 {lab=AVSS}
N 3430 -280 3460 -280 {lab=SEL_IOUT}
N 3500 -190 3550 -190 {lab=AVSS}
N 3430 -190 3460 -190 {lab=SEL_IOUT}
N 3500 -250 3500 -220 {lab=#net26}
N 3760 -280 3810 -280 {lab=AVSS}
N 3690 -280 3720 -280 {lab=SEL_IOUT}
N 3760 -190 3810 -190 {lab=AVSS}
N 3690 -190 3720 -190 {lab=SEL_IOUT}
N 3760 -250 3760 -220 {lab=#net27}
N 4020 -280 4070 -280 {lab=AVSS}
N 3950 -280 3980 -280 {lab=SEL_IOUT}
N 4020 -190 4070 -190 {lab=AVSS}
N 3950 -190 3980 -190 {lab=SEL_IOUT}
N 4020 -250 4020 -220 {lab=#net28}
N 4270 -280 4320 -280 {lab=AVSS}
N 4200 -280 4230 -280 {lab=SEL_IOUT}
N 4270 -190 4320 -190 {lab=AVSS}
N 4200 -190 4230 -190 {lab=SEL_IOUT}
N 4270 -250 4270 -220 {lab=#net29}
N 390 -1290 390 -1170 {lab=IOUT}
N 680 -1800 680 -1770 {lab=AVDD}
N 680 -1800 850 -1800 {lab=AVDD}
N 850 -1800 850 -1750 {lab=AVDD}
N 680 -1670 680 -1640 {lab=AVSS}
N 680 -1640 850 -1640 {lab=AVSS}
N 850 -1690 850 -1640 {lab=AVSS}
N 710 -1150 760 -1150 {lab=AVSS}
N 650 -1150 670 -1150 {lab=IREF}
N 710 -1120 710 -1055 {lab=#net30}
N 650 -1150 650 -1025 {lab=IREF}
N 760 -945 760 -865 {lab=AVSS}
N 710 -1025 760 -1025 {lab=AVSS}
N 650 -945 650 -865 {lab=IREF}
N 650 -945 670 -945 {lab=IREF}
N 710 -945 760 -945 {lab=AVSS}
N 760 -785 760 -705 {lab=AVSS}
N 710 -835 710 -815 {lab=#net31}
N 650 -865 670 -865 {lab=IREF}
N 650 -820 650 -785 {lab=IREF}
N 650 -785 670 -785 {lab=IREF}
N 710 -865 760 -865 {lab=AVSS}
N 760 -820 760 -785 {lab=AVSS}
N 710 -785 760 -785 {lab=AVSS}
N 760 -625 760 -545 {lab=AVSS}
N 710 -675 710 -655 {lab=#net32}
N 650 -705 670 -705 {lab=IREF}
N 650 -625 670 -625 {lab=IREF}
N 650 -705 650 -625 {lab=IREF}
N 710 -705 760 -705 {lab=AVSS}
N 710 -625 760 -625 {lab=AVSS}
N 760 -705 760 -625 {lab=AVSS}
N 710 -755 710 -735 {lab=#net33}
N 650 -785 650 -705 {lab=IREF}
N 710 -515 710 -495 {lab=#net34}
N 650 -545 670 -545 {lab=IREF}
N 650 -465 670 -465 {lab=IREF}
N 650 -545 650 -465 {lab=IREF}
N 710 -545 760 -545 {lab=AVSS}
N 710 -465 760 -465 {lab=AVSS}
N 760 -545 760 -465 {lab=AVSS}
N 710 -595 710 -575 {lab=#net35}
N 650 -625 650 -545 {lab=IREF}
N 710 -435 710 -415 {lab=#net36}
N 650 -465 650 -385 {lab=IREF}
N 650 -385 670 -385 {lab=IREF}
N 710 -385 760 -385 {lab=AVSS}
N 710 -915 710 -895 {lab=#net37}
N 710 -995 710 -975 {lab=#net38}
N 650 -1025 650 -945 {lab=IREF}
N 760 -1025 760 -945 {lab=AVSS}
N 760 -465 760 -385 {lab=AVSS}
N 650 -1025 670 -1025 {lab=IREF}
N 760 -1150 760 -1025 {lab=AVSS}
N 630 -820 650 -820 {lab=IREF}
N 650 -865 650 -820 {lab=IREF}
N 760 -820 790 -820 {lab=AVSS}
N 760 -865 760 -820 {lab=AVSS}
N 710 -370 710 -310 {lab=#net39}
N 960 -1160 1010 -1160 {lab=AVSS}
N 900 -1160 920 -1160 {lab=IREF}
N 960 -1130 960 -1065 {lab=#net40}
N 900 -1160 900 -1035 {lab=IREF}
N 1010 -955 1010 -875 {lab=AVSS}
N 960 -1035 1010 -1035 {lab=AVSS}
N 900 -955 900 -875 {lab=IREF}
N 900 -955 920 -955 {lab=IREF}
N 960 -955 1010 -955 {lab=AVSS}
N 1010 -795 1010 -715 {lab=AVSS}
N 960 -845 960 -825 {lab=#net41}
N 900 -875 920 -875 {lab=IREF}
N 900 -830 900 -795 {lab=IREF}
N 900 -795 920 -795 {lab=IREF}
N 960 -875 1010 -875 {lab=AVSS}
N 1010 -830 1010 -795 {lab=AVSS}
N 960 -795 1010 -795 {lab=AVSS}
N 1010 -635 1010 -555 {lab=AVSS}
N 960 -685 960 -665 {lab=#net42}
N 900 -715 920 -715 {lab=IREF}
N 900 -635 920 -635 {lab=IREF}
N 900 -715 900 -635 {lab=IREF}
N 960 -715 1010 -715 {lab=AVSS}
N 960 -635 1010 -635 {lab=AVSS}
N 1010 -715 1010 -635 {lab=AVSS}
N 960 -765 960 -745 {lab=#net43}
N 900 -795 900 -715 {lab=IREF}
N 960 -525 960 -505 {lab=#net44}
N 900 -555 920 -555 {lab=IREF}
N 900 -475 920 -475 {lab=IREF}
N 900 -555 900 -475 {lab=IREF}
N 960 -555 1010 -555 {lab=AVSS}
N 960 -475 1010 -475 {lab=AVSS}
N 1010 -555 1010 -475 {lab=AVSS}
N 960 -605 960 -585 {lab=#net45}
N 900 -635 900 -555 {lab=IREF}
N 960 -445 960 -425 {lab=#net46}
N 900 -475 900 -395 {lab=IREF}
N 900 -395 920 -395 {lab=IREF}
N 960 -395 1010 -395 {lab=AVSS}
N 960 -925 960 -905 {lab=#net47}
N 960 -1005 960 -985 {lab=#net48}
N 900 -1035 900 -955 {lab=IREF}
N 1010 -1035 1010 -955 {lab=AVSS}
N 1010 -475 1010 -395 {lab=AVSS}
N 900 -1035 920 -1035 {lab=IREF}
N 1010 -1160 1010 -1035 {lab=AVSS}
N 880 -830 900 -830 {lab=IREF}
N 900 -875 900 -830 {lab=IREF}
N 1010 -830 1040 -830 {lab=AVSS}
N 1010 -875 1010 -830 {lab=AVSS}
N 1220 -1160 1270 -1160 {lab=AVSS}
N 1160 -1160 1180 -1160 {lab=IREF}
N 1220 -1130 1220 -1065 {lab=#net49}
N 1160 -1160 1160 -1035 {lab=IREF}
N 1270 -955 1270 -875 {lab=AVSS}
N 1220 -1035 1270 -1035 {lab=AVSS}
N 1160 -955 1160 -875 {lab=IREF}
N 1160 -955 1180 -955 {lab=IREF}
N 1220 -955 1270 -955 {lab=AVSS}
N 1270 -795 1270 -715 {lab=AVSS}
N 1220 -845 1220 -825 {lab=#net50}
N 1160 -875 1180 -875 {lab=IREF}
N 1160 -830 1160 -795 {lab=IREF}
N 1160 -795 1180 -795 {lab=IREF}
N 1220 -875 1270 -875 {lab=AVSS}
N 1270 -830 1270 -795 {lab=AVSS}
N 1220 -795 1270 -795 {lab=AVSS}
N 1270 -635 1270 -555 {lab=AVSS}
N 1220 -685 1220 -665 {lab=#net51}
N 1160 -715 1180 -715 {lab=IREF}
N 1160 -635 1180 -635 {lab=IREF}
N 1160 -715 1160 -635 {lab=IREF}
N 1220 -715 1270 -715 {lab=AVSS}
N 1220 -635 1270 -635 {lab=AVSS}
N 1270 -715 1270 -635 {lab=AVSS}
N 1220 -765 1220 -745 {lab=#net52}
N 1160 -795 1160 -715 {lab=IREF}
N 1220 -525 1220 -505 {lab=#net53}
N 1160 -555 1180 -555 {lab=IREF}
N 1160 -475 1180 -475 {lab=IREF}
N 1160 -555 1160 -475 {lab=IREF}
N 1220 -555 1270 -555 {lab=AVSS}
N 1220 -475 1270 -475 {lab=AVSS}
N 1270 -555 1270 -475 {lab=AVSS}
N 1220 -605 1220 -585 {lab=#net54}
N 1160 -635 1160 -555 {lab=IREF}
N 1220 -445 1220 -425 {lab=#net55}
N 1160 -475 1160 -395 {lab=IREF}
N 1160 -395 1180 -395 {lab=IREF}
N 1220 -395 1270 -395 {lab=AVSS}
N 1220 -925 1220 -905 {lab=#net56}
N 1220 -1005 1220 -985 {lab=#net57}
N 1160 -1035 1160 -955 {lab=IREF}
N 1270 -1035 1270 -955 {lab=AVSS}
N 1270 -475 1270 -395 {lab=AVSS}
N 1160 -1035 1180 -1035 {lab=IREF}
N 1270 -1160 1270 -1035 {lab=AVSS}
N 1140 -830 1160 -830 {lab=IREF}
N 1160 -875 1160 -830 {lab=IREF}
N 1270 -830 1300 -830 {lab=AVSS}
N 1270 -875 1270 -830 {lab=AVSS}
N 1470 -1160 1520 -1160 {lab=AVSS}
N 1410 -1160 1430 -1160 {lab=IREF}
N 1470 -1130 1470 -1065 {lab=#net58}
N 1410 -1160 1410 -1035 {lab=IREF}
N 1520 -955 1520 -875 {lab=AVSS}
N 1470 -1035 1520 -1035 {lab=AVSS}
N 1410 -955 1410 -875 {lab=IREF}
N 1410 -955 1430 -955 {lab=IREF}
N 1470 -955 1520 -955 {lab=AVSS}
N 1520 -795 1520 -715 {lab=AVSS}
N 1470 -845 1470 -825 {lab=#net59}
N 1410 -875 1430 -875 {lab=IREF}
N 1410 -830 1410 -795 {lab=IREF}
N 1410 -795 1430 -795 {lab=IREF}
N 1470 -875 1520 -875 {lab=AVSS}
N 1520 -830 1520 -795 {lab=AVSS}
N 1470 -795 1520 -795 {lab=AVSS}
N 1520 -635 1520 -555 {lab=AVSS}
N 1470 -685 1470 -665 {lab=#net60}
N 1410 -715 1430 -715 {lab=IREF}
N 1410 -635 1430 -635 {lab=IREF}
N 1410 -715 1410 -635 {lab=IREF}
N 1470 -715 1520 -715 {lab=AVSS}
N 1470 -635 1520 -635 {lab=AVSS}
N 1520 -715 1520 -635 {lab=AVSS}
N 1470 -765 1470 -745 {lab=#net61}
N 1410 -795 1410 -715 {lab=IREF}
N 1470 -525 1470 -505 {lab=#net62}
N 1410 -555 1430 -555 {lab=IREF}
N 1410 -475 1430 -475 {lab=IREF}
N 1410 -555 1410 -475 {lab=IREF}
N 1470 -555 1520 -555 {lab=AVSS}
N 1470 -475 1520 -475 {lab=AVSS}
N 1520 -555 1520 -475 {lab=AVSS}
N 1470 -605 1470 -585 {lab=#net63}
N 1410 -635 1410 -555 {lab=IREF}
N 1470 -445 1470 -425 {lab=#net64}
N 1410 -475 1410 -395 {lab=IREF}
N 1410 -395 1430 -395 {lab=IREF}
N 1470 -395 1520 -395 {lab=AVSS}
N 1470 -925 1470 -905 {lab=#net65}
N 1470 -1005 1470 -985 {lab=#net66}
N 1410 -1035 1410 -955 {lab=IREF}
N 1520 -1035 1520 -955 {lab=AVSS}
N 1520 -475 1520 -395 {lab=AVSS}
N 1410 -1035 1430 -1035 {lab=IREF}
N 1520 -1160 1520 -1035 {lab=AVSS}
N 1390 -830 1410 -830 {lab=IREF}
N 1410 -875 1410 -830 {lab=IREF}
N 1520 -830 1550 -830 {lab=AVSS}
N 1520 -875 1520 -830 {lab=AVSS}
N 1730 -1160 1780 -1160 {lab=AVSS}
N 1670 -1160 1690 -1160 {lab=IREF}
N 1730 -1130 1730 -1065 {lab=#net67}
N 1670 -1160 1670 -1035 {lab=IREF}
N 1780 -955 1780 -875 {lab=AVSS}
N 1730 -1035 1780 -1035 {lab=AVSS}
N 1670 -955 1670 -875 {lab=IREF}
N 1670 -955 1690 -955 {lab=IREF}
N 1730 -955 1780 -955 {lab=AVSS}
N 1780 -795 1780 -715 {lab=AVSS}
N 1730 -845 1730 -825 {lab=#net68}
N 1670 -875 1690 -875 {lab=IREF}
N 1670 -830 1670 -795 {lab=IREF}
N 1670 -795 1690 -795 {lab=IREF}
N 1730 -875 1780 -875 {lab=AVSS}
N 1780 -830 1780 -795 {lab=AVSS}
N 1730 -795 1780 -795 {lab=AVSS}
N 1780 -635 1780 -555 {lab=AVSS}
N 1730 -685 1730 -665 {lab=#net69}
N 1670 -715 1690 -715 {lab=IREF}
N 1670 -635 1690 -635 {lab=IREF}
N 1670 -715 1670 -635 {lab=IREF}
N 1730 -715 1780 -715 {lab=AVSS}
N 1730 -635 1780 -635 {lab=AVSS}
N 1780 -715 1780 -635 {lab=AVSS}
N 1730 -765 1730 -745 {lab=#net70}
N 1670 -795 1670 -715 {lab=IREF}
N 1730 -525 1730 -505 {lab=#net71}
N 1670 -555 1690 -555 {lab=IREF}
N 1670 -475 1690 -475 {lab=IREF}
N 1670 -555 1670 -475 {lab=IREF}
N 1730 -555 1780 -555 {lab=AVSS}
N 1730 -475 1780 -475 {lab=AVSS}
N 1780 -555 1780 -475 {lab=AVSS}
N 1730 -605 1730 -585 {lab=#net72}
N 1670 -635 1670 -555 {lab=IREF}
N 1730 -445 1730 -425 {lab=#net73}
N 1670 -475 1670 -395 {lab=IREF}
N 1670 -395 1690 -395 {lab=IREF}
N 1730 -395 1780 -395 {lab=AVSS}
N 1730 -925 1730 -905 {lab=#net74}
N 1730 -1005 1730 -985 {lab=#net75}
N 1670 -1035 1670 -955 {lab=IREF}
N 1780 -1035 1780 -955 {lab=AVSS}
N 1780 -475 1780 -395 {lab=AVSS}
N 1670 -1035 1690 -1035 {lab=IREF}
N 1780 -1160 1780 -1035 {lab=AVSS}
N 1650 -830 1670 -830 {lab=IREF}
N 1670 -875 1670 -830 {lab=IREF}
N 1780 -830 1810 -830 {lab=AVSS}
N 1780 -875 1780 -830 {lab=AVSS}
N 1980 -1160 2030 -1160 {lab=AVSS}
N 1920 -1160 1940 -1160 {lab=IREF}
N 1980 -1130 1980 -1065 {lab=#net76}
N 1920 -1160 1920 -1035 {lab=IREF}
N 2030 -955 2030 -875 {lab=AVSS}
N 1980 -1035 2030 -1035 {lab=AVSS}
N 1920 -955 1920 -875 {lab=IREF}
N 1920 -955 1940 -955 {lab=IREF}
N 1980 -955 2030 -955 {lab=AVSS}
N 2030 -795 2030 -715 {lab=AVSS}
N 1980 -845 1980 -825 {lab=#net77}
N 1920 -875 1940 -875 {lab=IREF}
N 1920 -830 1920 -795 {lab=IREF}
N 1920 -795 1940 -795 {lab=IREF}
N 1980 -875 2030 -875 {lab=AVSS}
N 2030 -830 2030 -795 {lab=AVSS}
N 1980 -795 2030 -795 {lab=AVSS}
N 2030 -635 2030 -555 {lab=AVSS}
N 1980 -685 1980 -665 {lab=#net78}
N 1920 -715 1940 -715 {lab=IREF}
N 1920 -635 1940 -635 {lab=IREF}
N 1920 -715 1920 -635 {lab=IREF}
N 1980 -715 2030 -715 {lab=AVSS}
N 1980 -635 2030 -635 {lab=AVSS}
N 2030 -715 2030 -635 {lab=AVSS}
N 1980 -765 1980 -745 {lab=#net79}
N 1920 -795 1920 -715 {lab=IREF}
N 1980 -525 1980 -505 {lab=#net80}
N 1920 -555 1940 -555 {lab=IREF}
N 1920 -475 1940 -475 {lab=IREF}
N 1920 -555 1920 -475 {lab=IREF}
N 1980 -555 2030 -555 {lab=AVSS}
N 1980 -475 2030 -475 {lab=AVSS}
N 2030 -555 2030 -475 {lab=AVSS}
N 1980 -605 1980 -585 {lab=#net81}
N 1920 -635 1920 -555 {lab=IREF}
N 1980 -445 1980 -425 {lab=#net82}
N 1920 -475 1920 -395 {lab=IREF}
N 1920 -395 1940 -395 {lab=IREF}
N 1980 -395 2030 -395 {lab=AVSS}
N 1980 -925 1980 -905 {lab=#net83}
N 1980 -1005 1980 -985 {lab=#net84}
N 1920 -1035 1920 -955 {lab=IREF}
N 2030 -1035 2030 -955 {lab=AVSS}
N 2030 -475 2030 -395 {lab=AVSS}
N 1920 -1035 1940 -1035 {lab=IREF}
N 2030 -1160 2030 -1035 {lab=AVSS}
N 1900 -830 1920 -830 {lab=IREF}
N 1920 -875 1920 -830 {lab=IREF}
N 2030 -830 2060 -830 {lab=AVSS}
N 2030 -875 2030 -830 {lab=AVSS}
N 2240 -1160 2290 -1160 {lab=AVSS}
N 2180 -1160 2200 -1160 {lab=IREF}
N 2240 -1130 2240 -1065 {lab=#net85}
N 2180 -1160 2180 -1035 {lab=IREF}
N 2290 -955 2290 -875 {lab=AVSS}
N 2240 -1035 2290 -1035 {lab=AVSS}
N 2180 -955 2180 -875 {lab=IREF}
N 2180 -955 2200 -955 {lab=IREF}
N 2240 -955 2290 -955 {lab=AVSS}
N 2290 -795 2290 -715 {lab=AVSS}
N 2240 -845 2240 -825 {lab=#net86}
N 2180 -875 2200 -875 {lab=IREF}
N 2180 -830 2180 -795 {lab=IREF}
N 2180 -795 2200 -795 {lab=IREF}
N 2240 -875 2290 -875 {lab=AVSS}
N 2290 -830 2290 -795 {lab=AVSS}
N 2240 -795 2290 -795 {lab=AVSS}
N 2290 -635 2290 -555 {lab=AVSS}
N 2240 -685 2240 -665 {lab=#net87}
N 2180 -715 2200 -715 {lab=IREF}
N 2180 -635 2200 -635 {lab=IREF}
N 2180 -715 2180 -635 {lab=IREF}
N 2240 -715 2290 -715 {lab=AVSS}
N 2240 -635 2290 -635 {lab=AVSS}
N 2290 -715 2290 -635 {lab=AVSS}
N 2240 -765 2240 -745 {lab=#net88}
N 2180 -795 2180 -715 {lab=IREF}
N 2240 -525 2240 -505 {lab=#net89}
N 2180 -555 2200 -555 {lab=IREF}
N 2180 -475 2200 -475 {lab=IREF}
N 2180 -555 2180 -475 {lab=IREF}
N 2240 -555 2290 -555 {lab=AVSS}
N 2240 -475 2290 -475 {lab=AVSS}
N 2290 -555 2290 -475 {lab=AVSS}
N 2240 -605 2240 -585 {lab=#net90}
N 2180 -635 2180 -555 {lab=IREF}
N 2240 -445 2240 -425 {lab=#net91}
N 2180 -475 2180 -395 {lab=IREF}
N 2180 -395 2200 -395 {lab=IREF}
N 2240 -395 2290 -395 {lab=AVSS}
N 2240 -925 2240 -905 {lab=#net92}
N 2240 -1005 2240 -985 {lab=#net93}
N 2180 -1035 2180 -955 {lab=IREF}
N 2290 -1035 2290 -955 {lab=AVSS}
N 2290 -475 2290 -395 {lab=AVSS}
N 2180 -1035 2200 -1035 {lab=IREF}
N 2290 -1160 2290 -1035 {lab=AVSS}
N 2160 -830 2180 -830 {lab=IREF}
N 2180 -875 2180 -830 {lab=IREF}
N 2290 -830 2320 -830 {lab=AVSS}
N 2290 -875 2290 -830 {lab=AVSS}
N 2490 -1160 2540 -1160 {lab=AVSS}
N 2430 -1160 2450 -1160 {lab=IREF}
N 2490 -1130 2490 -1065 {lab=#net94}
N 2430 -1160 2430 -1035 {lab=IREF}
N 2540 -955 2540 -875 {lab=AVSS}
N 2490 -1035 2540 -1035 {lab=AVSS}
N 2430 -955 2430 -875 {lab=IREF}
N 2430 -955 2450 -955 {lab=IREF}
N 2490 -955 2540 -955 {lab=AVSS}
N 2540 -795 2540 -715 {lab=AVSS}
N 2490 -845 2490 -825 {lab=#net95}
N 2430 -875 2450 -875 {lab=IREF}
N 2430 -830 2430 -795 {lab=IREF}
N 2430 -795 2450 -795 {lab=IREF}
N 2490 -875 2540 -875 {lab=AVSS}
N 2540 -830 2540 -795 {lab=AVSS}
N 2490 -795 2540 -795 {lab=AVSS}
N 2540 -635 2540 -555 {lab=AVSS}
N 2490 -685 2490 -665 {lab=#net96}
N 2430 -715 2450 -715 {lab=IREF}
N 2430 -635 2450 -635 {lab=IREF}
N 2430 -715 2430 -635 {lab=IREF}
N 2490 -715 2540 -715 {lab=AVSS}
N 2490 -635 2540 -635 {lab=AVSS}
N 2540 -715 2540 -635 {lab=AVSS}
N 2490 -765 2490 -745 {lab=#net97}
N 2430 -795 2430 -715 {lab=IREF}
N 2490 -525 2490 -505 {lab=#net98}
N 2430 -555 2450 -555 {lab=IREF}
N 2430 -475 2450 -475 {lab=IREF}
N 2430 -555 2430 -475 {lab=IREF}
N 2490 -555 2540 -555 {lab=AVSS}
N 2490 -475 2540 -475 {lab=AVSS}
N 2540 -555 2540 -475 {lab=AVSS}
N 2490 -605 2490 -585 {lab=#net99}
N 2430 -635 2430 -555 {lab=IREF}
N 2490 -445 2490 -425 {lab=#net100}
N 2430 -475 2430 -395 {lab=IREF}
N 2430 -395 2450 -395 {lab=IREF}
N 2490 -395 2540 -395 {lab=AVSS}
N 2490 -925 2490 -905 {lab=#net101}
N 2490 -1005 2490 -985 {lab=#net102}
N 2430 -1035 2430 -955 {lab=IREF}
N 2540 -1035 2540 -955 {lab=AVSS}
N 2540 -475 2540 -395 {lab=AVSS}
N 2430 -1035 2450 -1035 {lab=IREF}
N 2540 -1160 2540 -1035 {lab=AVSS}
N 2410 -830 2430 -830 {lab=IREF}
N 2430 -875 2430 -830 {lab=IREF}
N 2540 -830 2570 -830 {lab=AVSS}
N 2540 -875 2540 -830 {lab=AVSS}
N 2740 -1160 2790 -1160 {lab=AVSS}
N 2680 -1160 2700 -1160 {lab=IREF}
N 2740 -1130 2740 -1065 {lab=#net103}
N 2680 -1160 2680 -1035 {lab=IREF}
N 2790 -955 2790 -875 {lab=AVSS}
N 2740 -1035 2790 -1035 {lab=AVSS}
N 2680 -955 2680 -875 {lab=IREF}
N 2680 -955 2700 -955 {lab=IREF}
N 2740 -955 2790 -955 {lab=AVSS}
N 2790 -795 2790 -715 {lab=AVSS}
N 2740 -845 2740 -825 {lab=#net104}
N 2680 -875 2700 -875 {lab=IREF}
N 2680 -830 2680 -795 {lab=IREF}
N 2680 -795 2700 -795 {lab=IREF}
N 2740 -875 2790 -875 {lab=AVSS}
N 2790 -830 2790 -795 {lab=AVSS}
N 2740 -795 2790 -795 {lab=AVSS}
N 2790 -635 2790 -555 {lab=AVSS}
N 2740 -685 2740 -665 {lab=#net105}
N 2680 -715 2700 -715 {lab=IREF}
N 2680 -635 2700 -635 {lab=IREF}
N 2680 -715 2680 -635 {lab=IREF}
N 2740 -715 2790 -715 {lab=AVSS}
N 2740 -635 2790 -635 {lab=AVSS}
N 2790 -715 2790 -635 {lab=AVSS}
N 2740 -765 2740 -745 {lab=#net106}
N 2680 -795 2680 -715 {lab=IREF}
N 2740 -525 2740 -505 {lab=#net107}
N 2680 -555 2700 -555 {lab=IREF}
N 2680 -475 2700 -475 {lab=IREF}
N 2680 -555 2680 -475 {lab=IREF}
N 2740 -555 2790 -555 {lab=AVSS}
N 2740 -475 2790 -475 {lab=AVSS}
N 2790 -555 2790 -475 {lab=AVSS}
N 2740 -605 2740 -585 {lab=#net108}
N 2680 -635 2680 -555 {lab=IREF}
N 2740 -445 2740 -425 {lab=#net109}
N 2680 -475 2680 -395 {lab=IREF}
N 2680 -395 2700 -395 {lab=IREF}
N 2740 -395 2790 -395 {lab=AVSS}
N 2740 -925 2740 -905 {lab=#net110}
N 2740 -1005 2740 -985 {lab=#net111}
N 2680 -1035 2680 -955 {lab=IREF}
N 2790 -1035 2790 -955 {lab=AVSS}
N 2790 -475 2790 -395 {lab=AVSS}
N 2680 -1035 2700 -1035 {lab=IREF}
N 2790 -1160 2790 -1035 {lab=AVSS}
N 2660 -830 2680 -830 {lab=IREF}
N 2680 -875 2680 -830 {lab=IREF}
N 2790 -830 2820 -830 {lab=AVSS}
N 2790 -875 2790 -830 {lab=AVSS}
N 2990 -1160 3040 -1160 {lab=AVSS}
N 2930 -1160 2950 -1160 {lab=IREF}
N 2990 -1130 2990 -1065 {lab=#net112}
N 2930 -1160 2930 -1035 {lab=IREF}
N 3040 -955 3040 -875 {lab=AVSS}
N 2990 -1035 3040 -1035 {lab=AVSS}
N 2930 -955 2930 -875 {lab=IREF}
N 2930 -955 2950 -955 {lab=IREF}
N 2990 -955 3040 -955 {lab=AVSS}
N 3040 -795 3040 -715 {lab=AVSS}
N 2990 -845 2990 -825 {lab=#net113}
N 2930 -875 2950 -875 {lab=IREF}
N 2930 -830 2930 -795 {lab=IREF}
N 2930 -795 2950 -795 {lab=IREF}
N 2990 -875 3040 -875 {lab=AVSS}
N 3040 -830 3040 -795 {lab=AVSS}
N 2990 -795 3040 -795 {lab=AVSS}
N 3040 -635 3040 -555 {lab=AVSS}
N 2990 -685 2990 -665 {lab=#net114}
N 2930 -715 2950 -715 {lab=IREF}
N 2930 -635 2950 -635 {lab=IREF}
N 2930 -715 2930 -635 {lab=IREF}
N 2990 -715 3040 -715 {lab=AVSS}
N 2990 -635 3040 -635 {lab=AVSS}
N 3040 -715 3040 -635 {lab=AVSS}
N 2990 -765 2990 -745 {lab=#net115}
N 2930 -795 2930 -715 {lab=IREF}
N 2990 -525 2990 -505 {lab=#net116}
N 2930 -555 2950 -555 {lab=IREF}
N 2930 -475 2950 -475 {lab=IREF}
N 2930 -555 2930 -475 {lab=IREF}
N 2990 -555 3040 -555 {lab=AVSS}
N 2990 -475 3040 -475 {lab=AVSS}
N 3040 -555 3040 -475 {lab=AVSS}
N 2990 -605 2990 -585 {lab=#net117}
N 2930 -635 2930 -555 {lab=IREF}
N 2990 -445 2990 -425 {lab=#net118}
N 2930 -475 2930 -395 {lab=IREF}
N 2930 -395 2950 -395 {lab=IREF}
N 2990 -395 3040 -395 {lab=AVSS}
N 2990 -925 2990 -905 {lab=#net119}
N 2990 -1005 2990 -985 {lab=#net120}
N 2930 -1035 2930 -955 {lab=IREF}
N 3040 -1035 3040 -955 {lab=AVSS}
N 3040 -475 3040 -395 {lab=AVSS}
N 2930 -1035 2950 -1035 {lab=IREF}
N 3040 -1160 3040 -1035 {lab=AVSS}
N 2910 -830 2930 -830 {lab=IREF}
N 2930 -875 2930 -830 {lab=IREF}
N 3040 -830 3070 -830 {lab=AVSS}
N 3040 -875 3040 -830 {lab=AVSS}
N 3250 -1160 3300 -1160 {lab=AVSS}
N 3190 -1160 3210 -1160 {lab=IREF}
N 3250 -1130 3250 -1065 {lab=#net121}
N 3190 -1160 3190 -1035 {lab=IREF}
N 3300 -955 3300 -875 {lab=AVSS}
N 3250 -1035 3300 -1035 {lab=AVSS}
N 3190 -955 3190 -875 {lab=IREF}
N 3190 -955 3210 -955 {lab=IREF}
N 3250 -955 3300 -955 {lab=AVSS}
N 3300 -795 3300 -715 {lab=AVSS}
N 3250 -845 3250 -825 {lab=#net122}
N 3190 -875 3210 -875 {lab=IREF}
N 3190 -830 3190 -795 {lab=IREF}
N 3190 -795 3210 -795 {lab=IREF}
N 3250 -875 3300 -875 {lab=AVSS}
N 3300 -830 3300 -795 {lab=AVSS}
N 3250 -795 3300 -795 {lab=AVSS}
N 3300 -635 3300 -555 {lab=AVSS}
N 3250 -685 3250 -665 {lab=#net123}
N 3190 -715 3210 -715 {lab=IREF}
N 3190 -635 3210 -635 {lab=IREF}
N 3190 -715 3190 -635 {lab=IREF}
N 3250 -715 3300 -715 {lab=AVSS}
N 3250 -635 3300 -635 {lab=AVSS}
N 3300 -715 3300 -635 {lab=AVSS}
N 3250 -765 3250 -745 {lab=#net124}
N 3190 -795 3190 -715 {lab=IREF}
N 3250 -525 3250 -505 {lab=#net125}
N 3190 -555 3210 -555 {lab=IREF}
N 3190 -475 3210 -475 {lab=IREF}
N 3190 -555 3190 -475 {lab=IREF}
N 3250 -555 3300 -555 {lab=AVSS}
N 3250 -475 3300 -475 {lab=AVSS}
N 3300 -555 3300 -475 {lab=AVSS}
N 3250 -605 3250 -585 {lab=#net126}
N 3190 -635 3190 -555 {lab=IREF}
N 3250 -445 3250 -425 {lab=#net127}
N 3190 -475 3190 -395 {lab=IREF}
N 3190 -395 3210 -395 {lab=IREF}
N 3250 -395 3300 -395 {lab=AVSS}
N 3250 -925 3250 -905 {lab=#net128}
N 3250 -1005 3250 -985 {lab=#net129}
N 3190 -1035 3190 -955 {lab=IREF}
N 3300 -1035 3300 -955 {lab=AVSS}
N 3300 -475 3300 -395 {lab=AVSS}
N 3190 -1035 3210 -1035 {lab=IREF}
N 3300 -1160 3300 -1035 {lab=AVSS}
N 3170 -830 3190 -830 {lab=IREF}
N 3190 -875 3190 -830 {lab=IREF}
N 3300 -830 3330 -830 {lab=AVSS}
N 3300 -875 3300 -830 {lab=AVSS}
N 3500 -1160 3550 -1160 {lab=AVSS}
N 3440 -1160 3460 -1160 {lab=IREF}
N 3500 -1130 3500 -1065 {lab=#net130}
N 3440 -1160 3440 -1035 {lab=IREF}
N 3550 -955 3550 -875 {lab=AVSS}
N 3500 -1035 3550 -1035 {lab=AVSS}
N 3440 -955 3440 -875 {lab=IREF}
N 3440 -955 3460 -955 {lab=IREF}
N 3500 -955 3550 -955 {lab=AVSS}
N 3550 -795 3550 -715 {lab=AVSS}
N 3500 -845 3500 -825 {lab=#net131}
N 3440 -875 3460 -875 {lab=IREF}
N 3440 -830 3440 -795 {lab=IREF}
N 3440 -795 3460 -795 {lab=IREF}
N 3500 -875 3550 -875 {lab=AVSS}
N 3550 -830 3550 -795 {lab=AVSS}
N 3500 -795 3550 -795 {lab=AVSS}
N 3550 -635 3550 -555 {lab=AVSS}
N 3500 -685 3500 -665 {lab=#net132}
N 3440 -715 3460 -715 {lab=IREF}
N 3440 -635 3460 -635 {lab=IREF}
N 3440 -715 3440 -635 {lab=IREF}
N 3500 -715 3550 -715 {lab=AVSS}
N 3500 -635 3550 -635 {lab=AVSS}
N 3550 -715 3550 -635 {lab=AVSS}
N 3500 -765 3500 -745 {lab=#net133}
N 3440 -795 3440 -715 {lab=IREF}
N 3500 -525 3500 -505 {lab=#net134}
N 3440 -555 3460 -555 {lab=IREF}
N 3440 -475 3460 -475 {lab=IREF}
N 3440 -555 3440 -475 {lab=IREF}
N 3500 -555 3550 -555 {lab=AVSS}
N 3500 -475 3550 -475 {lab=AVSS}
N 3550 -555 3550 -475 {lab=AVSS}
N 3500 -605 3500 -585 {lab=#net135}
N 3440 -635 3440 -555 {lab=IREF}
N 3500 -445 3500 -425 {lab=#net136}
N 3440 -475 3440 -395 {lab=IREF}
N 3440 -395 3460 -395 {lab=IREF}
N 3500 -395 3550 -395 {lab=AVSS}
N 3500 -925 3500 -905 {lab=#net137}
N 3500 -1005 3500 -985 {lab=#net138}
N 3440 -1035 3440 -955 {lab=IREF}
N 3550 -1035 3550 -955 {lab=AVSS}
N 3550 -475 3550 -395 {lab=AVSS}
N 3440 -1035 3460 -1035 {lab=IREF}
N 3550 -1160 3550 -1035 {lab=AVSS}
N 3420 -830 3440 -830 {lab=IREF}
N 3440 -875 3440 -830 {lab=IREF}
N 3550 -830 3580 -830 {lab=AVSS}
N 3550 -875 3550 -830 {lab=AVSS}
N 3760 -1160 3810 -1160 {lab=AVSS}
N 3700 -1160 3720 -1160 {lab=IREF}
N 3760 -1130 3760 -1065 {lab=#net139}
N 3700 -1160 3700 -1035 {lab=IREF}
N 3810 -955 3810 -875 {lab=AVSS}
N 3760 -1035 3810 -1035 {lab=AVSS}
N 3700 -955 3700 -875 {lab=IREF}
N 3700 -955 3720 -955 {lab=IREF}
N 3760 -955 3810 -955 {lab=AVSS}
N 3810 -795 3810 -715 {lab=AVSS}
N 3760 -845 3760 -825 {lab=#net140}
N 3700 -875 3720 -875 {lab=IREF}
N 3700 -830 3700 -795 {lab=IREF}
N 3700 -795 3720 -795 {lab=IREF}
N 3760 -875 3810 -875 {lab=AVSS}
N 3810 -830 3810 -795 {lab=AVSS}
N 3760 -795 3810 -795 {lab=AVSS}
N 3810 -635 3810 -555 {lab=AVSS}
N 3760 -685 3760 -665 {lab=#net141}
N 3700 -715 3720 -715 {lab=IREF}
N 3700 -635 3720 -635 {lab=IREF}
N 3700 -715 3700 -635 {lab=IREF}
N 3760 -715 3810 -715 {lab=AVSS}
N 3760 -635 3810 -635 {lab=AVSS}
N 3810 -715 3810 -635 {lab=AVSS}
N 3760 -765 3760 -745 {lab=#net142}
N 3700 -795 3700 -715 {lab=IREF}
N 3760 -525 3760 -505 {lab=#net143}
N 3700 -555 3720 -555 {lab=IREF}
N 3700 -475 3720 -475 {lab=IREF}
N 3700 -555 3700 -475 {lab=IREF}
N 3760 -555 3810 -555 {lab=AVSS}
N 3760 -475 3810 -475 {lab=AVSS}
N 3810 -555 3810 -475 {lab=AVSS}
N 3760 -605 3760 -585 {lab=#net144}
N 3700 -635 3700 -555 {lab=IREF}
N 3760 -445 3760 -425 {lab=#net145}
N 3700 -475 3700 -395 {lab=IREF}
N 3700 -395 3720 -395 {lab=IREF}
N 3760 -395 3810 -395 {lab=AVSS}
N 3760 -925 3760 -905 {lab=#net146}
N 3760 -1005 3760 -985 {lab=#net147}
N 3700 -1035 3700 -955 {lab=IREF}
N 3810 -1035 3810 -955 {lab=AVSS}
N 3810 -475 3810 -395 {lab=AVSS}
N 3700 -1035 3720 -1035 {lab=IREF}
N 3810 -1160 3810 -1035 {lab=AVSS}
N 3680 -830 3700 -830 {lab=IREF}
N 3700 -875 3700 -830 {lab=IREF}
N 3810 -830 3840 -830 {lab=AVSS}
N 3810 -875 3810 -830 {lab=AVSS}
N 4020 -1160 4070 -1160 {lab=AVSS}
N 3960 -1160 3980 -1160 {lab=IREF}
N 4020 -1130 4020 -1065 {lab=#net148}
N 3960 -1160 3960 -1035 {lab=IREF}
N 4070 -955 4070 -875 {lab=AVSS}
N 4020 -1035 4070 -1035 {lab=AVSS}
N 3960 -955 3960 -875 {lab=IREF}
N 3960 -955 3980 -955 {lab=IREF}
N 4020 -955 4070 -955 {lab=AVSS}
N 4070 -795 4070 -715 {lab=AVSS}
N 4020 -845 4020 -825 {lab=#net149}
N 3960 -875 3980 -875 {lab=IREF}
N 3960 -830 3960 -795 {lab=IREF}
N 3960 -795 3980 -795 {lab=IREF}
N 4020 -875 4070 -875 {lab=AVSS}
N 4070 -830 4070 -795 {lab=AVSS}
N 4020 -795 4070 -795 {lab=AVSS}
N 4070 -635 4070 -555 {lab=AVSS}
N 4020 -685 4020 -665 {lab=#net150}
N 3960 -715 3980 -715 {lab=IREF}
N 3960 -635 3980 -635 {lab=IREF}
N 3960 -715 3960 -635 {lab=IREF}
N 4020 -715 4070 -715 {lab=AVSS}
N 4020 -635 4070 -635 {lab=AVSS}
N 4070 -715 4070 -635 {lab=AVSS}
N 4020 -765 4020 -745 {lab=#net151}
N 3960 -795 3960 -715 {lab=IREF}
N 4020 -525 4020 -505 {lab=#net152}
N 3960 -555 3980 -555 {lab=IREF}
N 3960 -475 3980 -475 {lab=IREF}
N 3960 -555 3960 -475 {lab=IREF}
N 4020 -555 4070 -555 {lab=AVSS}
N 4020 -475 4070 -475 {lab=AVSS}
N 4070 -555 4070 -475 {lab=AVSS}
N 4020 -605 4020 -585 {lab=#net153}
N 3960 -635 3960 -555 {lab=IREF}
N 4020 -445 4020 -425 {lab=#net154}
N 3960 -475 3960 -395 {lab=IREF}
N 3960 -395 3980 -395 {lab=IREF}
N 4020 -395 4070 -395 {lab=AVSS}
N 4020 -925 4020 -905 {lab=#net155}
N 4020 -1005 4020 -985 {lab=#net156}
N 3960 -1035 3960 -955 {lab=IREF}
N 4070 -1035 4070 -955 {lab=AVSS}
N 4070 -475 4070 -395 {lab=AVSS}
N 3960 -1035 3980 -1035 {lab=IREF}
N 4070 -1160 4070 -1035 {lab=AVSS}
N 3940 -830 3960 -830 {lab=IREF}
N 3960 -875 3960 -830 {lab=IREF}
N 4070 -830 4100 -830 {lab=AVSS}
N 4070 -875 4070 -830 {lab=AVSS}
N 4270 -1160 4320 -1160 {lab=AVSS}
N 4210 -1160 4230 -1160 {lab=IREF}
N 4270 -1130 4270 -1065 {lab=#net157}
N 4210 -1160 4210 -1035 {lab=IREF}
N 4320 -955 4320 -875 {lab=AVSS}
N 4270 -1035 4320 -1035 {lab=AVSS}
N 4210 -955 4210 -875 {lab=IREF}
N 4210 -955 4230 -955 {lab=IREF}
N 4270 -955 4320 -955 {lab=AVSS}
N 4320 -795 4320 -715 {lab=AVSS}
N 4270 -845 4270 -825 {lab=#net158}
N 4210 -875 4230 -875 {lab=IREF}
N 4210 -830 4210 -795 {lab=IREF}
N 4210 -795 4230 -795 {lab=IREF}
N 4270 -875 4320 -875 {lab=AVSS}
N 4320 -830 4320 -795 {lab=AVSS}
N 4270 -795 4320 -795 {lab=AVSS}
N 4320 -635 4320 -555 {lab=AVSS}
N 4270 -685 4270 -665 {lab=#net159}
N 4210 -715 4230 -715 {lab=IREF}
N 4210 -635 4230 -635 {lab=IREF}
N 4210 -715 4210 -635 {lab=IREF}
N 4270 -715 4320 -715 {lab=AVSS}
N 4270 -635 4320 -635 {lab=AVSS}
N 4320 -715 4320 -635 {lab=AVSS}
N 4270 -765 4270 -745 {lab=#net160}
N 4210 -795 4210 -715 {lab=IREF}
N 4270 -525 4270 -505 {lab=#net161}
N 4210 -555 4230 -555 {lab=IREF}
N 4210 -475 4230 -475 {lab=IREF}
N 4210 -555 4210 -475 {lab=IREF}
N 4270 -555 4320 -555 {lab=AVSS}
N 4270 -475 4320 -475 {lab=AVSS}
N 4320 -555 4320 -475 {lab=AVSS}
N 4270 -605 4270 -585 {lab=#net162}
N 4210 -635 4210 -555 {lab=IREF}
N 4270 -445 4270 -425 {lab=#net163}
N 4210 -475 4210 -395 {lab=IREF}
N 4210 -395 4230 -395 {lab=IREF}
N 4270 -395 4320 -395 {lab=AVSS}
N 4270 -925 4270 -905 {lab=#net164}
N 4270 -1005 4270 -985 {lab=#net165}
N 4210 -1035 4210 -955 {lab=IREF}
N 4320 -1035 4320 -955 {lab=AVSS}
N 4320 -475 4320 -395 {lab=AVSS}
N 4210 -1035 4230 -1035 {lab=IREF}
N 4320 -1160 4320 -1035 {lab=AVSS}
N 4190 -830 4210 -830 {lab=IREF}
N 4210 -875 4210 -830 {lab=IREF}
N 4320 -830 4350 -830 {lab=AVSS}
N 4320 -875 4320 -830 {lab=AVSS}
N 1730 -1300 1730 -1190 {lab=IOUT}
N 1980 -1300 1980 -1190 {lab=IOUT}
N 2240 -1300 2240 -1190 {lab=IOUT}
N 2490 -1300 2490 -1190 {lab=IOUT}
N 2740 -1300 2740 -1190 {lab=IOUT}
N 2990 -1300 2990 -1190 {lab=IOUT}
N 3250 -1300 3250 -1190 {lab=IOUT}
N 3500 -1300 3500 -1190 {lab=IOUT}
N 3760 -1300 3760 -1190 {lab=IOUT}
N 4020 -1300 4020 -1190 {lab=IOUT}
N 4270 -1300 4270 -1190 {lab=IOUT}
N 710 -1300 710 -1180 {lab=IOUT}
N 960 -1300 960 -1190 {lab=IOUT}
N 1220 -1300 1220 -1190 {lab=IOUT}
N 1470 -1300 1470 -1190 {lab=IOUT}
N 110 -1140 160 -1140 {lab=AVSS}
N 200 -1140 220 -1140 {lab=IREF}
N 160 -1110 160 -1045 {lab=#net166}
N 220 -1080 220 -1015 {lab=IREF}
N 160 -345 160 -310 {lab=#net167}
N 110 -935 110 -855 {lab=AVSS}
N 110 -1015 160 -1015 {lab=AVSS}
N 220 -935 220 -855 {lab=IREF}
N 200 -935 220 -935 {lab=IREF}
N 110 -935 160 -935 {lab=AVSS}
N 110 -775 110 -695 {lab=AVSS}
N 160 -825 160 -805 {lab=#net168}
N 200 -855 220 -855 {lab=IREF}
N 220 -855 220 -775 {lab=IREF}
N 200 -775 220 -775 {lab=IREF}
N 110 -855 160 -855 {lab=AVSS}
N 110 -855 110 -775 {lab=AVSS}
N 110 -775 160 -775 {lab=AVSS}
N 110 -560 110 -535 {lab=AVSS}
N 160 -665 160 -645 {lab=#net169}
N 200 -695 220 -695 {lab=IREF}
N 200 -615 220 -615 {lab=IREF}
N 220 -695 220 -615 {lab=IREF}
N 110 -695 160 -695 {lab=AVSS}
N 110 -615 160 -615 {lab=AVSS}
N 110 -695 110 -615 {lab=AVSS}
N 160 -745 160 -725 {lab=#net170}
N 220 -775 220 -695 {lab=IREF}
N 160 -505 160 -485 {lab=#net171}
N 200 -535 220 -535 {lab=IREF}
N 200 -455 220 -455 {lab=IREF}
N 220 -535 220 -455 {lab=IREF}
N 110 -535 160 -535 {lab=AVSS}
N 110 -455 160 -455 {lab=AVSS}
N 110 -535 110 -455 {lab=AVSS}
N 160 -585 160 -565 {lab=#net172}
N 220 -615 220 -535 {lab=IREF}
N 160 -425 160 -405 {lab=#net173}
N 220 -455 220 -375 {lab=IREF}
N 200 -375 220 -375 {lab=IREF}
N 110 -375 160 -375 {lab=AVSS}
N 160 -905 160 -885 {lab=#net174}
N 160 -985 160 -965 {lab=#net175}
N 220 -1015 220 -935 {lab=IREF}
N 110 -1015 110 -935 {lab=AVSS}
N 110 -455 110 -375 {lab=AVSS}
N 200 -1015 220 -1015 {lab=IREF}
N 110 -1140 110 -1015 {lab=AVSS}
N 390 -1140 440 -1140 {lab=AVSS}
N 330 -1140 350 -1140 {lab=IREF}
N 390 -1110 390 -1045 {lab=#net177}
N 330 -1080 330 -1015 {lab=IREF}
N 390 -345 390 -310 {lab=#net178}
N 440 -935 440 -855 {lab=AVSS}
N 390 -1015 440 -1015 {lab=AVSS}
N 330 -935 330 -855 {lab=IREF}
N 330 -935 350 -935 {lab=IREF}
N 390 -935 440 -935 {lab=AVSS}
N 440 -775 440 -695 {lab=AVSS}
N 390 -825 390 -805 {lab=#net179}
N 330 -855 350 -855 {lab=IREF}
N 330 -855 330 -775 {lab=IREF}
N 330 -775 350 -775 {lab=IREF}
N 390 -855 440 -855 {lab=AVSS}
N 440 -855 440 -775 {lab=AVSS}
N 390 -775 440 -775 {lab=AVSS}
N 390 -665 390 -645 {lab=#net180}
N 330 -695 350 -695 {lab=IREF}
N 330 -615 350 -615 {lab=IREF}
N 330 -695 330 -615 {lab=IREF}
N 390 -695 440 -695 {lab=AVSS}
N 390 -615 440 -615 {lab=AVSS}
N 440 -695 440 -615 {lab=AVSS}
N 390 -745 390 -725 {lab=#net181}
N 330 -775 330 -695 {lab=IREF}
N 390 -505 390 -485 {lab=#net182}
N 330 -535 350 -535 {lab=IREF}
N 330 -455 350 -455 {lab=IREF}
N 330 -535 330 -455 {lab=IREF}
N 390 -535 440 -535 {lab=AVSS}
N 390 -455 440 -455 {lab=AVSS}
N 440 -535 440 -455 {lab=AVSS}
N 390 -585 390 -565 {lab=#net183}
N 330 -615 330 -535 {lab=IREF}
N 390 -425 390 -405 {lab=#net184}
N 330 -455 330 -375 {lab=IREF}
N 330 -375 350 -375 {lab=IREF}
N 390 -375 440 -375 {lab=AVSS}
N 390 -905 390 -885 {lab=#net185}
N 390 -985 390 -965 {lab=#net186}
N 330 -1015 330 -935 {lab=IREF}
N 440 -1015 440 -935 {lab=AVSS}
N 440 -455 440 -375 {lab=AVSS}
N 330 -1015 350 -1015 {lab=IREF}
N 440 -1140 440 -1015 {lab=AVSS}
N 220 -1200 220 -1140 {lab=IREF}
N 160 -1200 220 -1200 {lab=IREF}
N 30 -560 110 -560 {lab=AVSS}
N 110 -615 110 -560 {lab=AVSS}
N 440 -570 440 -535 {lab=AVSS}
N 440 -570 480 -570 {lab=AVSS}
N 440 -615 440 -570 {lab=AVSS}
N 220 -1080 330 -1080 {lab=IREF}
N 220 -1140 220 -1080 {lab=IREF}
N 330 -1140 330 -1080 {lab=IREF}
C {sg13g2_pr/sg13_lv_nmos.sym} 140 -280 0 0 {name=M3
l=2u
w=2u
ng=1
m=2
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -280 0 0 {name=M4
l=2u
w=2u
ng=1
m=2
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 430 -280 0 1 {name=p2 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 190 -280 0 1 {name=p3 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 390 -220 3 0 {name=p5 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 160 -220 3 0 {name=p6 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 710 -130 3 0 {name=p9 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -280 0 0 {name=M8
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1000 -280 0 1 {name=p11 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 960 -130 3 0 {name=p12 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1220 -130 3 0 {name=p15 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1470 -130 3 0 {name=p18 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1730 -130 3 0 {name=p21 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1980 -130 3 0 {name=p24 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2240 -130 3 0 {name=p27 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2490 -130 3 0 {name=p30 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2740 -130 3 0 {name=p33 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2990 -130 3 0 {name=p36 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3250 -130 3 0 {name=p39 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3500 -130 3 0 {name=p42 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3760 -130 3 0 {name=p45 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4020 -130 3 0 {name=p48 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4270 -130 3 0 {name=p51 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 390 -1270 0 0 {name=p53 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 160 -1250 0 0 {name=p54 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 710 -1270 0 0 {name=p55 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 960 -1290 0 0 {name=p56 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 1220 -1290 0 0 {name=p57 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 1470 -1280 0 0 {name=p58 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 1730 -1280 0 0 {name=p59 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 1980 -1290 0 0 {name=p60 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 2240 -1280 0 0 {name=p61 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 2490 -1290 0 0 {name=p62 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 2740 -1280 0 0 {name=p63 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 2990 -1290 0 0 {name=p64 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 3250 -1290 0 0 {name=p65 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 3500 -1290 0 0 {name=p66 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 3760 -1280 0 0 {name=p67 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 4020 -1280 0 0 {name=p68 sig_type=std_logic lab=IOUT}
C {lab_wire.sym} 4270 -1290 0 0 {name=p69 sig_type=std_logic lab=IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1150 -1720 0 0 {name=M35
l=2u
w=2u
ng=1
m=2
model=sg13_lv_nmos
spiceprefix=X
}
C {iopin.sym} 210 -1740 0 0 {name=p85 lab=AVDD}
C {iopin.sym} 210 -1710 0 0 {name=p86 lab=AVSS}
C {iopin.sym} 210 -1680 0 0 {name=p87 lab=EN}
C {iopin.sym} 210 -1650 0 0 {name=p88 lab=ENB}
C {iopin.sym} 210 -1620 0 0 {name=p89 lab=SEL}
C {iopin.sym} 210 -1590 0 0 {name=p90 lab=IREF}
C {iopin.sym} 210 -1560 0 0 {name=p91 lab=IOUT}
C {lab_wire.sym} 580 -1740 0 0 {name=p92 sig_type=std_logic lab=EN}
C {lab_wire.sym} 580 -1700 0 0 {name=p93 sig_type=std_logic lab=SEL}
C {lab_wire.sym} 1090 -1720 0 0 {name=p94 sig_type=std_logic lab=ENB}
C {lab_wire.sym} 1170 -1790 0 0 {name=p95 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 1170 -1650 0 0 {name=p96 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 780 -1720 0 0 {name=p97 sig_type=std_logic lab=SELB}
C {lab_wire.sym} 930 -1720 0 1 {name=p98 sig_type=std_logic lab=SEL_IOUT}
C {lab_wire.sym} 900 -280 0 0 {name=p100 sig_type=std_logic lab=SEL_IOUT}
C {lab_wire.sym} 330 -280 0 0 {name=p101 sig_type=std_logic lab=EN}
C {lab_wire.sym} 100 -280 0 0 {name=p102 sig_type=std_logic lab=EN}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -190 0 0 {name=M2
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1000 -190 0 1 {name=p116 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 900 -190 0 0 {name=p131 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -280 0 0 {name=M1
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 750 -280 0 1 {name=p8 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 650 -280 0 0 {name=p84 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -190 0 0 {name=M6
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 750 -190 0 1 {name=p99 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 650 -190 0 0 {name=p130 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -280 0 0 {name=M5
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1260 -280 0 1 {name=p14 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1160 -280 0 0 {name=p17 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -190 0 0 {name=M7
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1260 -190 0 1 {name=p20 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1160 -190 0 0 {name=p23 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -280 0 0 {name=M9
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1510 -280 0 1 {name=p26 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1410 -280 0 0 {name=p29 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -190 0 0 {name=M10
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1510 -190 0 1 {name=p32 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1410 -190 0 0 {name=p35 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -280 0 0 {name=M11
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1770 -280 0 1 {name=p38 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1670 -280 0 0 {name=p41 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -190 0 0 {name=M12
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1770 -190 0 1 {name=p44 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1670 -190 0 0 {name=p47 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -280 0 0 {name=M13
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2020 -280 0 1 {name=p50 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1920 -280 0 0 {name=p103 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -190 0 0 {name=M14
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2020 -190 0 1 {name=p104 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1920 -190 0 0 {name=p105 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -280 0 0 {name=M15
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2280 -280 0 1 {name=p106 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2180 -280 0 0 {name=p107 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -190 0 0 {name=M16
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2280 -190 0 1 {name=p108 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2180 -190 0 0 {name=p109 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -280 0 0 {name=M17
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2530 -280 0 1 {name=p110 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2430 -280 0 0 {name=p111 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -190 0 0 {name=M18
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2530 -190 0 1 {name=p112 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2430 -190 0 0 {name=p113 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -280 0 0 {name=M19
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2780 -280 0 1 {name=p114 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2680 -280 0 0 {name=p115 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -190 0 0 {name=M20
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2780 -190 0 1 {name=p117 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2680 -190 0 0 {name=p118 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -280 0 0 {name=M21
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3030 -280 0 1 {name=p119 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2930 -280 0 0 {name=p120 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -190 0 0 {name=M22
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3030 -190 0 1 {name=p121 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2930 -190 0 0 {name=p122 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -280 0 0 {name=M23
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3290 -280 0 1 {name=p123 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3190 -280 0 0 {name=p124 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -190 0 0 {name=M24
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3290 -190 0 1 {name=p125 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3190 -190 0 0 {name=p126 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -280 0 0 {name=M25
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3540 -280 0 1 {name=p127 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3440 -280 0 0 {name=p128 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -190 0 0 {name=M26
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3540 -190 0 1 {name=p129 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3440 -190 0 0 {name=p132 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -280 0 0 {name=M27
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3800 -280 0 1 {name=p133 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3700 -280 0 0 {name=p134 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -190 0 0 {name=M28
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3800 -190 0 1 {name=p135 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3700 -190 0 0 {name=p136 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -280 0 0 {name=M29
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 4060 -280 0 1 {name=p137 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3960 -280 0 0 {name=p138 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -190 0 0 {name=M30
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 4060 -190 0 1 {name=p139 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3960 -190 0 0 {name=p140 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -280 0 0 {name=M31
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 4310 -280 0 1 {name=p141 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4210 -280 0 0 {name=p142 sig_type=std_logic lab=SEL_IOUT}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -190 0 0 {name=M32
l=6u
w=1u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 4310 -190 0 1 {name=p143 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4210 -190 0 0 {name=p144 sig_type=std_logic lab=SEL_IOUT}
C {inverter.sym} 840 -1720 0 0 {name=x20}
C {nand.sym} 680 -1720 0 0 {name=x21}
C {lab_wire.sym} 760 -1800 0 0 {name=p145 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 770 -1640 0 0 {name=p146 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -1150 0 0 {name=M33
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -1025 0 0 {name=M34
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -945 0 0 {name=M36
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -865 0 0 {name=M37
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -785 0 0 {name=M38
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -705 0 0 {name=M39
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -625 0 0 {name=M40
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -545 0 0 {name=M41
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -465 0 0 {name=M42
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 690 -385 0 0 {name=M43
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 630 -820 0 0 {name=p147 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 770 -820 0 1 {name=p148 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -1160 0 0 {name=M44
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -1035 0 0 {name=M45
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -955 0 0 {name=M46
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -875 0 0 {name=M47
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -795 0 0 {name=M48
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -715 0 0 {name=M49
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -635 0 0 {name=M50
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -555 0 0 {name=M51
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -475 0 0 {name=M52
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 940 -395 0 0 {name=M53
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 880 -830 0 0 {name=p1 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 1020 -830 0 1 {name=p7 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -1160 0 0 {name=M54
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -1035 0 0 {name=M55
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -955 0 0 {name=M56
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -875 0 0 {name=M57
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -795 0 0 {name=M58
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -715 0 0 {name=M59
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -635 0 0 {name=M60
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -555 0 0 {name=M61
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -475 0 0 {name=M62
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1200 -395 0 0 {name=M63
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1140 -830 0 0 {name=p10 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 1280 -830 0 1 {name=p13 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -1160 0 0 {name=M64
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -1035 0 0 {name=M65
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -955 0 0 {name=M66
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -875 0 0 {name=M67
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -795 0 0 {name=M68
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -715 0 0 {name=M69
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -635 0 0 {name=M70
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -555 0 0 {name=M71
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -475 0 0 {name=M72
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1450 -395 0 0 {name=M73
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1390 -830 0 0 {name=p16 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 1530 -830 0 1 {name=p19 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -1160 0 0 {name=M74
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -1035 0 0 {name=M75
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -955 0 0 {name=M76
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -875 0 0 {name=M77
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -795 0 0 {name=M78
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -715 0 0 {name=M79
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -635 0 0 {name=M80
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -555 0 0 {name=M81
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -475 0 0 {name=M82
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1710 -395 0 0 {name=M83
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1650 -830 0 0 {name=p22 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 1790 -830 0 1 {name=p25 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -1160 0 0 {name=M84
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -1035 0 0 {name=M85
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -955 0 0 {name=M86
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -875 0 0 {name=M87
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -795 0 0 {name=M88
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -715 0 0 {name=M89
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -635 0 0 {name=M90
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -555 0 0 {name=M91
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -475 0 0 {name=M92
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 1960 -395 0 0 {name=M93
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 1900 -830 0 0 {name=p28 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 2040 -830 0 1 {name=p31 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -1160 0 0 {name=M94
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -1035 0 0 {name=M95
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -955 0 0 {name=M96
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -875 0 0 {name=M97
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -795 0 0 {name=M98
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -715 0 0 {name=M99
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -635 0 0 {name=M100
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -555 0 0 {name=M101
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -475 0 0 {name=M102
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2220 -395 0 0 {name=M103
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2160 -830 0 0 {name=p34 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 2300 -830 0 1 {name=p37 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -1160 0 0 {name=M104
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -1035 0 0 {name=M105
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -955 0 0 {name=M106
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -875 0 0 {name=M107
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -795 0 0 {name=M108
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -715 0 0 {name=M109
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -635 0 0 {name=M110
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -555 0 0 {name=M111
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -475 0 0 {name=M112
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2470 -395 0 0 {name=M113
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2410 -830 0 0 {name=p40 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 2550 -830 0 1 {name=p43 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -1160 0 0 {name=M114
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -1035 0 0 {name=M115
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -955 0 0 {name=M116
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -875 0 0 {name=M117
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -795 0 0 {name=M118
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -715 0 0 {name=M119
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -635 0 0 {name=M120
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -555 0 0 {name=M121
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -475 0 0 {name=M122
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2720 -395 0 0 {name=M123
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2660 -830 0 0 {name=p46 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 2800 -830 0 1 {name=p49 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -1160 0 0 {name=M124
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -1035 0 0 {name=M125
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -955 0 0 {name=M126
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -875 0 0 {name=M127
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -795 0 0 {name=M128
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -715 0 0 {name=M129
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -635 0 0 {name=M130
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -555 0 0 {name=M131
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -475 0 0 {name=M132
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 2970 -395 0 0 {name=M133
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 2910 -830 0 0 {name=p70 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 3050 -830 0 1 {name=p71 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -1160 0 0 {name=M134
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -1035 0 0 {name=M135
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -955 0 0 {name=M136
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -875 0 0 {name=M137
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -795 0 0 {name=M138
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -715 0 0 {name=M139
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -635 0 0 {name=M140
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -555 0 0 {name=M141
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -475 0 0 {name=M142
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3230 -395 0 0 {name=M143
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3170 -830 0 0 {name=p72 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 3310 -830 0 1 {name=p73 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -1160 0 0 {name=M144
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -1035 0 0 {name=M145
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -955 0 0 {name=M146
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -875 0 0 {name=M147
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -795 0 0 {name=M148
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -715 0 0 {name=M149
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -635 0 0 {name=M150
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -555 0 0 {name=M151
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -475 0 0 {name=M152
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3480 -395 0 0 {name=M153
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3420 -830 0 0 {name=p74 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 3560 -830 0 1 {name=p75 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -1160 0 0 {name=M154
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -1035 0 0 {name=M155
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -955 0 0 {name=M156
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -875 0 0 {name=M157
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -795 0 0 {name=M158
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -715 0 0 {name=M159
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -635 0 0 {name=M160
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -555 0 0 {name=M161
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -475 0 0 {name=M162
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 3740 -395 0 0 {name=M163
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3680 -830 0 0 {name=p76 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 3820 -830 0 1 {name=p77 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -1160 0 0 {name=M164
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -1035 0 0 {name=M165
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -955 0 0 {name=M166
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -875 0 0 {name=M167
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -795 0 0 {name=M168
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -715 0 0 {name=M169
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -635 0 0 {name=M170
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -555 0 0 {name=M171
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -475 0 0 {name=M172
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4000 -395 0 0 {name=M173
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 3940 -830 0 0 {name=p78 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 4080 -830 0 1 {name=p79 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -1160 0 0 {name=M174
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -1035 0 0 {name=M175
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -955 0 0 {name=M176
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -875 0 0 {name=M177
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -795 0 0 {name=M178
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -715 0 0 {name=M179
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -635 0 0 {name=M180
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -555 0 0 {name=M181
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -475 0 0 {name=M182
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 4250 -395 0 0 {name=M183
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 4190 -830 0 0 {name=p80 sig_type=std_logic lab=IREF}
C {lab_wire.sym} 4330 -830 0 1 {name=p81 sig_type=std_logic lab=AVSS}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -1140 0 1 {name=M184
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -1015 0 1 {name=M185
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -935 0 1 {name=M186
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -855 0 1 {name=M187
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -775 0 1 {name=M188
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -695 0 1 {name=M189
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -615 0 1 {name=M190
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -535 0 1 {name=M191
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -455 0 1 {name=M192
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 180 -375 0 1 {name=M193
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -1140 0 0 {name=M194
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -1015 0 0 {name=M195
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -935 0 0 {name=M196
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -855 0 0 {name=M197
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -775 0 0 {name=M198
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -695 0 0 {name=M199
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -615 0 0 {name=M200
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -535 0 0 {name=M201
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -455 0 0 {name=M202
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_nmos.sym} 370 -375 0 0 {name=M203
l=2u
w=2u
ng=1
m=1
model=sg13_lv_nmos
spiceprefix=X
}
C {lab_wire.sym} 30 -560 0 1 {name=p4 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 480 -570 0 1 {name=p52 sig_type=std_logic lab=AVSS}
