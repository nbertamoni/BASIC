v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {dac_top.sym} 30 -50 0 0 {name=x1}
