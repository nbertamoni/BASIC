v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 1530 -1580 1580 -1580 {lab=VBIAS}
N 1350 -1000 1350 -960 {lab=AVDD}
N 1480 -1390 1480 -1350 {lab=AVDD}
N 1350 -780 1350 -740 {lab=AVSS}
N 1160 -890 1200 -890 {lab=SEL}
N 1160 -870 1200 -870 {lab=en_bb}
N 1160 -850 1200 -850 {lab=en_b}
N 1290 -1270 1330 -1270 {lab=en_bb}
N 1630 -1270 1670 -1270 {lab=AVSS}
N 1480 -1190 1480 -1150 {lab=AVSS}
N 2010 -430 2050 -430 {lab=en}
N 2130 -430 2200 -430 {lab=en_b}
N 2280 -430 2320 -430 {lab=en_bb}
N 1240 -1290 1330 -1290 {lab=VBIAS}
N 1240 -1290 1240 -1150 {lab=VBIAS}
N 1240 -1150 1410 -1150 {lab=VBIAS}
N 1410 -1190 1410 -1150 {lab=VBIAS}
N 1660 -520 1720 -520 {lab=sign}
N 1660 -500 1720 -500 {lab=sign_b}
N 1510 -430 1510 -400 {lab=AVSS}
N 1510 -630 1510 -590 {lab=AVDD}
N 1310 -520 1360 -520 {lab=i_sign}
N 1310 -500 1360 -500 {lab=i_signb}
N 1070 -960 1290 -960 {lab=IBIAS}
N 1070 -1120 1070 -960 {lab=IBIAS}
N 1410 -1150 1410 -960 {lab=VBIAS}
N 2100 -700 2160 -700 {lab=sign}
N 2100 -680 2160 -680 {lab=sign_b}
N 2460 -710 2500 -710 {lab=CC_P}
N 2460 -690 2500 -690 {lab=CC_N}
N 2310 -620 2310 -590 {lab=AVSS}
N 2120 -720 2160 -720 {lab=ISUM}
N 2120 -740 2120 -720 {lab=ISUM}
N 2020 -740 2120 -740 {lab=ISUM}
N 1530 -1910 1580 -1910 {lab=AVDD}
N 1530 -1880 1580 -1880 {lab=AVSS}
N 1530 -1820 1580 -1820 {lab=DATA[17:0]}
N 1530 -1850 1580 -1850 {lab=en}
N 1530 -1790 1580 -1790 {lab=IBIAS}
N 1530 -1760 1580 -1760 {lab=SEL}
N 1530 -1730 1580 -1730 {lab=i_sign}
N 1530 -1650 1580 -1650 {lab=CC_P}
N 1530 -1620 1580 -1620 {lab=CC_N}
N 1240 -1350 1240 -1290 {lab=VBIAS}
N 1240 -1450 1240 -1410 {lab=AVDD}
N 3230 -1320 3230 -1280 {lab=AVDD}
N 3040 -1200 3080 -1200 {lab=en_bb}
N 3380 -1200 3430 -1200 {lab=DATA[0]}
N 3230 -1120 3230 -1080 {lab=AVSS}
N 2990 -1220 3080 -1220 {lab=VBIAS}
N 3160 -1120 3160 -1080 {lab=ISUM}
N 3230 -1050 3230 -1010 {lab=AVDD}
N 3040 -930 3080 -930 {lab=en_bb}
N 3380 -930 3430 -930 {lab=DATA[1]}
N 3230 -850 3230 -810 {lab=AVSS}
N 2990 -950 3080 -950 {lab=VBIAS}
N 3160 -850 3160 -810 {lab=ISUM}
N 3230 -780 3230 -740 {lab=AVDD}
N 3040 -660 3080 -660 {lab=en_bb}
N 3380 -660 3430 -660 {lab=DATA[2]}
N 3230 -580 3230 -540 {lab=AVSS}
N 2990 -680 3080 -680 {lab=VBIAS}
N 3160 -580 3160 -540 {lab=ISUM}
N 3930 -1340 3930 -1300 {lab=AVDD}
N 3740 -1220 3780 -1220 {lab=en_bb}
N 4080 -1220 4130 -1220 {lab=DATA[3]}
N 3930 -1140 3930 -1100 {lab=AVSS}
N 3690 -1240 3780 -1240 {lab=VBIAS}
N 3860 -1140 3860 -1100 {lab=ISUM}
N 3930 -1060 3930 -1020 {lab=AVDD}
N 3740 -940 3780 -940 {lab=en_bb}
N 4080 -940 4130 -940 {lab=DATA[4]}
N 3930 -860 3930 -820 {lab=AVSS}
N 3690 -960 3780 -960 {lab=VBIAS}
N 3860 -860 3860 -820 {lab=ISUM}
N 3930 -780 3930 -740 {lab=AVDD}
N 3740 -660 3780 -660 {lab=en_bb}
N 4080 -660 4130 -660 {lab=DATA[5]}
N 3930 -580 3930 -540 {lab=AVSS}
N 3690 -680 3780 -680 {lab=VBIAS}
N 3860 -580 3860 -540 {lab=ISUM}
N 3930 -500 3930 -460 {lab=AVDD}
N 3740 -380 3780 -380 {lab=en_bb}
N 4080 -380 4130 -380 {lab=DATA[6]}
N 3930 -300 3930 -260 {lab=AVSS}
N 3690 -400 3780 -400 {lab=VBIAS}
N 3860 -300 3860 -260 {lab=ISUM}
N 4660 -1310 4660 -1270 {lab=AVDD}
N 4470 -1190 4510 -1190 {lab=en_bb}
N 4810 -1190 4860 -1190 {lab=DATA[7]}
N 4660 -1110 4660 -1070 {lab=AVSS}
N 4420 -1210 4510 -1210 {lab=VBIAS}
N 4590 -1110 4590 -1070 {lab=ISUM}
N 4670 -1020 4670 -980 {lab=AVDD}
N 4480 -900 4520 -900 {lab=en_bb}
N 4820 -900 4870 -900 {lab=DATA[8]}
N 4670 -820 4670 -780 {lab=AVSS}
N 4430 -920 4520 -920 {lab=VBIAS}
N 4600 -820 4600 -780 {lab=ISUM}
N 4670 -740 4670 -700 {lab=AVDD}
N 4480 -620 4520 -620 {lab=en_bb}
N 4820 -620 4870 -620 {lab=DATA[9]}
N 4670 -540 4670 -500 {lab=AVSS}
N 4430 -640 4520 -640 {lab=VBIAS}
N 4600 -540 4600 -500 {lab=ISUM}
N 4670 -470 4670 -430 {lab=AVDD}
N 4480 -350 4520 -350 {lab=en_bb}
N 4820 -350 4870 -350 {lab=DATA[10]}
N 4670 -270 4670 -230 {lab=AVSS}
N 4430 -370 4520 -370 {lab=VBIAS}
N 4600 -270 4600 -230 {lab=ISUM}
N 5260 -1330 5260 -1290 {lab=AVDD}
N 5070 -1210 5110 -1210 {lab=en_bb}
N 5410 -1210 5460 -1210 {lab=DATA[11]}
N 5260 -1130 5260 -1090 {lab=AVSS}
N 5020 -1230 5110 -1230 {lab=VBIAS}
N 5190 -1130 5190 -1090 {lab=ISUM}
N 5280 -1020 5280 -980 {lab=AVDD}
N 5090 -900 5130 -900 {lab=en_bb}
N 5430 -900 5480 -900 {lab=DATA[12]}
N 5280 -820 5280 -780 {lab=AVSS}
N 5040 -920 5130 -920 {lab=VBIAS}
N 5210 -820 5210 -780 {lab=ISUM}
N 5280 -730 5280 -690 {lab=AVDD}
N 5090 -610 5130 -610 {lab=en_bb}
N 5430 -610 5480 -610 {lab=DATA[13]}
N 5280 -530 5280 -490 {lab=AVSS}
N 5040 -630 5130 -630 {lab=VBIAS}
N 5210 -530 5210 -490 {lab=ISUM}
N 5280 -450 5280 -410 {lab=AVDD}
N 5090 -330 5130 -330 {lab=en_bb}
N 5430 -330 5480 -330 {lab=DATA[14]}
N 5280 -250 5280 -210 {lab=AVSS}
N 5040 -350 5130 -350 {lab=VBIAS}
N 5210 -250 5210 -210 {lab=ISUM}
N 5950 -1310 5950 -1270 {lab=AVDD}
N 5760 -1190 5800 -1190 {lab=en_bb}
N 6100 -1190 6150 -1190 {lab=DATA[15]}
N 5950 -1110 5950 -1070 {lab=AVSS}
N 5710 -1210 5800 -1210 {lab=VBIAS}
N 5880 -1110 5880 -1070 {lab=ISUM}
N 5940 -1030 5940 -990 {lab=AVDD}
N 5750 -910 5790 -910 {lab=en_bb}
N 6090 -910 6140 -910 {lab=DATA[16]}
N 5940 -830 5940 -790 {lab=AVSS}
N 5870 -830 5870 -790 {lab=ISUM}
N 5940 -730 5940 -690 {lab=AVDD}
N 5750 -610 5790 -610 {lab=en_bb}
N 6090 -610 6140 -610 {lab=DATA[17]}
N 5940 -530 5940 -490 {lab=AVSS}
N 5870 -530 5870 -490 {lab=ISUM}
N 1530 -1690 1580 -1690 {lab=i_signb}
N 2240 -400 2240 -370 {lab=AVSS}
N 2090 -400 2090 -370 {lab=AVSS}
N 2090 -500 2090 -460 {lab=AVDD}
N 2240 -500 2240 -460 {lab=AVDD}
N 5700 -930 5790 -930 {lab=VBIAS}
N 5700 -630 5790 -630 {lab=VBIAS}
C {iopin.sym} 1530 -1580 2 0 {name=p11 lab=VBIAS}
C {current_mirror.sym} 1350 -870 0 0 {name=x8}
C {lab_wire.sym} 1350 -980 0 0 {name=p12 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -1150 0 0 {name=p13 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 1180 -890 0 0 {name=p14 sig_type=std_logic lab=SEL}
C {lab_wire.sym} 1190 -870 0 0 {name=p15 sig_type=std_logic lab=en_bb}
C {lab_wire.sym} 1190 -850 0 0 {name=p16 sig_type=std_logic lab=en_b}
C {lab_wire.sym} 1350 -750 0 0 {name=p17 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1480 -1160 0 0 {name=p18 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1480 -1380 0 0 {name=p19 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1320 -1270 0 0 {name=p21 sig_type=std_logic lab=en_bb}
C {lab_wire.sym} 1650 -1270 0 1 {name=p28 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2020 -430 0 0 {name=p44 sig_type=std_logic lab=en}
C {lab_wire.sym} 2180 -430 0 0 {name=p45 sig_type=std_logic lab=en_b}
C {lab_wire.sym} 1070 -1100 0 0 {name=p24 sig_type=std_logic lab=IBIAS}
C {lab_wire.sym} 2310 -430 0 1 {name=p50 sig_type=std_logic lab=en_bb}
C {non_overlap.sym} 1510 -510 0 0 {name=x6}
C {lab_wire.sym} 1710 -520 0 1 {name=p30 sig_type=std_logic lab=sign}
C {lab_wire.sym} 1710 -500 0 1 {name=p31 sig_type=std_logic lab=sign_b}
C {lab_wire.sym} 1510 -410 0 0 {name=p32 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 1510 -610 0 0 {name=p33 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 1330 -500 0 0 {name=p34 sig_type=std_logic lab=i_signb}
C {lab_wire.sym} 1330 -520 0 0 {name=p35 sig_type=std_logic lab=i_sign}
C {lab_wire.sym} 2490 -710 0 1 {name=p68 sig_type=std_logic lab=CC_P}
C {dsw.sym} 2310 -700 0 0 {name=x9}
C {lab_wire.sym} 2490 -690 0 1 {name=p107 sig_type=std_logic lab=CC_N}
C {lab_wire.sym} 2310 -600 0 0 {name=p108 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2110 -700 0 0 {name=p109 sig_type=std_logic lab=sign}
C {lab_wire.sym} 2110 -680 0 0 {name=p110 sig_type=std_logic lab=sign_b}
C {lab_wire.sym} 2070 -740 0 0 {name=p113 sig_type=std_logic lab=ISUM}
C {dac.sym} 1480 -1270 0 0 {name=x1[7:0]}
C {iopin.sym} 1530 -1910 2 0 {name=p721 lab=AVDD}
C {iopin.sym} 1530 -1880 2 0 {name=p722 lab=AVSS}
C {iopin.sym} 1530 -1850 2 0 {name=p724 lab=en}
C {iopin.sym} 1530 -1820 2 0 {name=p727 lab=DATA[17:0]}
C {iopin.sym} 1530 -1790 2 0 {name=p1 lab=IBIAS}
C {iopin.sym} 1530 -1760 2 0 {name=p2 lab=SEL}
C {iopin.sym} 1530 -1730 2 0 {name=p3 lab=i_sign}
C {iopin.sym} 1530 -1650 2 0 {name=p6 lab=CC_P}
C {iopin.sym} 1530 -1620 2 0 {name=p7 lab=CC_N}
C {sg13g2_pr/cap_cmim.sym} 1240 -1380 0 0 {name=C1
model=cap_cmim
w=18e-6
l=18e-6
m=80
spiceprefix=X}
C {lab_wire.sym} 1240 -1430 0 0 {name=p25 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3230 -1310 0 0 {name=p9 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3070 -1200 0 0 {name=p4 sig_type=std_logic lab=en_bb}
C {dac.sym} 3230 -1200 0 0 {name=xb0}
C {lab_wire.sym} 3070 -1220 0 0 {name=p36 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3230 -1090 0 1 {name=p37 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3160 -1100 0 0 {name=p38 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3230 -1040 0 0 {name=p27 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3070 -930 0 0 {name=p40 sig_type=std_logic lab=en_bb}
C {dac.sym} 3230 -930 0 0 {name=xb1[1:0]}
C {lab_wire.sym} 3070 -950 0 0 {name=p41 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3230 -820 0 1 {name=p42 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3160 -830 0 0 {name=p43 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3230 -770 0 0 {name=p47 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3070 -660 0 0 {name=p48 sig_type=std_logic lab=en_bb}
C {dac.sym} 3230 -660 0 0 {name=xb2[3:0]}
C {lab_wire.sym} 3070 -680 0 0 {name=p49 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3230 -550 0 1 {name=p55 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3160 -560 0 0 {name=p56 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3930 -1330 0 0 {name=p61 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3770 -1220 0 0 {name=p62 sig_type=std_logic lab=en_bb}
C {dac.sym} 3930 -1220 0 0 {name=xb3[7:0]}
C {lab_wire.sym} 3770 -1240 0 0 {name=p63 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3930 -1110 0 1 {name=p64 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3860 -1120 0 0 {name=p65 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3930 -1050 0 0 {name=p70 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3770 -940 0 0 {name=p71 sig_type=std_logic lab=en_bb}
C {dac.sym} 3930 -940 0 0 {name=xb4[7:0]}
C {lab_wire.sym} 3770 -960 0 0 {name=p72 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3930 -830 0 1 {name=p73 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3860 -840 0 0 {name=p74 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3930 -770 0 0 {name=p76 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3770 -660 0 0 {name=p77 sig_type=std_logic lab=en_bb}
C {dac.sym} 3930 -660 0 0 {name=xb5[7:0]}
C {lab_wire.sym} 3770 -680 0 0 {name=p78 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3930 -550 0 1 {name=p79 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3860 -560 0 0 {name=p80 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 3930 -490 0 0 {name=p82 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3770 -380 0 0 {name=p83 sig_type=std_logic lab=en_bb}
C {dac.sym} 3930 -380 0 0 {name=xb6[7:0]}
C {lab_wire.sym} 3770 -400 0 0 {name=p84 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 3930 -270 0 1 {name=p85 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 3860 -280 0 0 {name=p86 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4660 -1300 0 0 {name=p88 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4500 -1190 0 0 {name=p89 sig_type=std_logic lab=en_bb}
C {dac.sym} 4660 -1190 0 0 {name=xb7[7:0]}
C {lab_wire.sym} 4500 -1210 0 0 {name=p90 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4660 -1080 0 1 {name=p91 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4590 -1090 0 0 {name=p92 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4670 -1010 0 0 {name=p94 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4510 -900 0 0 {name=p95 sig_type=std_logic lab=en_bb}
C {dac.sym} 4670 -900 0 0 {name=xb8[7:0]}
C {lab_wire.sym} 4510 -920 0 0 {name=p96 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4670 -790 0 1 {name=p97 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4600 -800 0 0 {name=p98 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4670 -730 0 0 {name=p100 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4510 -620 0 0 {name=p101 sig_type=std_logic lab=en_bb}
C {dac.sym} 4670 -620 0 0 {name=xb9[7:0]}
C {lab_wire.sym} 4510 -640 0 0 {name=p102 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4670 -510 0 1 {name=p103 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4600 -520 0 0 {name=p104 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 4670 -460 0 0 {name=p106 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 4510 -350 0 0 {name=p111 sig_type=std_logic lab=en_bb}
C {dac.sym} 4670 -350 0 0 {name=xb10[7:0]}
C {lab_wire.sym} 4510 -370 0 0 {name=p112 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 4670 -240 0 1 {name=p114 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 4600 -250 0 0 {name=p115 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5260 -1310 0 0 {name=p117 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5100 -1210 0 0 {name=p118 sig_type=std_logic lab=en_bb}
C {dac.sym} 5260 -1210 0 0 {name=xb11[7:0]}
C {lab_wire.sym} 5100 -1230 0 0 {name=p119 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5260 -1100 0 1 {name=p120 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5190 -1110 0 0 {name=p121 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5280 -1010 0 0 {name=p123 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5120 -900 0 0 {name=p124 sig_type=std_logic lab=en_bb}
C {dac.sym} 5280 -900 0 0 {name=xb12[7:0]}
C {lab_wire.sym} 5120 -920 0 0 {name=p125 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5280 -790 0 1 {name=p126 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5210 -800 0 0 {name=p127 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5280 -720 0 0 {name=p129 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5120 -610 0 0 {name=p130 sig_type=std_logic lab=en_bb}
C {dac.sym} 5280 -610 0 0 {name=xb13[7:0]}
C {lab_wire.sym} 5120 -630 0 0 {name=p131 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5280 -500 0 1 {name=p132 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5210 -510 0 0 {name=p133 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5280 -440 0 0 {name=p135 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5120 -330 0 0 {name=p136 sig_type=std_logic lab=en_bb}
C {dac.sym} 5280 -330 0 0 {name=xb14[7:0]}
C {lab_wire.sym} 5120 -350 0 0 {name=p137 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5280 -220 0 1 {name=p138 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5210 -230 0 0 {name=p139 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5950 -1300 0 0 {name=p141 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5790 -1190 0 0 {name=p142 sig_type=std_logic lab=en_bb}
C {dac.sym} 5950 -1190 0 0 {name=xb15[7:0]}
C {lab_wire.sym} 5790 -1210 0 0 {name=p143 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5950 -1080 0 1 {name=p144 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5880 -1090 0 0 {name=p145 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5940 -1020 0 0 {name=p147 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5780 -910 0 0 {name=p148 sig_type=std_logic lab=en_bb}
C {dac.sym} 5940 -910 0 0 {name=xb16[7:0]}
C {lab_wire.sym} 5780 -930 0 0 {name=p149 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5940 -800 0 1 {name=p150 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5870 -810 0 0 {name=p151 sig_type=std_logic lab=ISUM}
C {lab_wire.sym} 5940 -720 0 0 {name=p153 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 5780 -610 0 0 {name=p154 sig_type=std_logic lab=en_bb}
C {dac.sym} 5940 -610 0 0 {name=xb17[7:0]}
C {lab_wire.sym} 5780 -630 0 0 {name=p155 sig_type=std_logic lab=VBIAS}
C {lab_wire.sym} 5940 -500 0 1 {name=p156 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 5870 -510 0 0 {name=p157 sig_type=std_logic lab=ISUM}
C {iopin.sym} 1530 -1690 2 0 {name=p5 lab=i_signb}
C {inverter.sym} 2080 -430 0 0 {name=x1}
C {inverter.sym} 2230 -430 0 0 {name=x2}
C {lab_wire.sym} 2240 -380 0 0 {name=p8 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2090 -380 0 0 {name=p10 sig_type=std_logic lab=AVSS}
C {lab_wire.sym} 2090 -480 0 0 {name=p20 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 2240 -480 0 0 {name=p22 sig_type=std_logic lab=AVDD}
C {lab_wire.sym} 3410 -1200 0 1 {name=p23 sig_type=std_logic lab=DATA[0]}
C {lab_wire.sym} 3410 -930 0 1 {name=p26 sig_type=std_logic lab=DATA[1]}
C {lab_wire.sym} 3410 -660 0 1 {name=p29 sig_type=std_logic lab=DATA[2]}
C {lab_wire.sym} 4110 -1220 0 1 {name=p39 sig_type=std_logic lab=DATA[3]}
C {lab_wire.sym} 4110 -940 0 1 {name=p46 sig_type=std_logic lab=DATA[4]}
C {lab_wire.sym} 4110 -660 0 1 {name=p51 sig_type=std_logic lab=DATA[5]}
C {lab_wire.sym} 4110 -380 0 1 {name=p52 sig_type=std_logic lab=DATA[6]}
C {lab_wire.sym} 4840 -1190 0 1 {name=p53 sig_type=std_logic lab=DATA[7]}
C {lab_wire.sym} 4840 -900 0 1 {name=p54 sig_type=std_logic lab=DATA[8]}
C {lab_wire.sym} 4850 -620 0 1 {name=p57 sig_type=std_logic lab=DATA[9]}
C {lab_wire.sym} 4850 -350 0 1 {name=p58 sig_type=std_logic lab=DATA[10]}
C {lab_wire.sym} 5440 -1210 0 1 {name=p59 sig_type=std_logic lab=DATA[11]}
C {lab_wire.sym} 5460 -900 0 1 {name=p60 sig_type=std_logic lab=DATA[12]}
C {lab_wire.sym} 5460 -610 0 1 {name=p66 sig_type=std_logic lab=DATA[13]}
C {lab_wire.sym} 5460 -330 0 1 {name=p67 sig_type=std_logic lab=DATA[14]}
C {lab_wire.sym} 6130 -1190 0 1 {name=p69 sig_type=std_logic lab=DATA[15]}
C {lab_wire.sym} 6120 -910 0 1 {name=p75 sig_type=std_logic lab=DATA[16]}
C {lab_wire.sym} 6120 -610 0 1 {name=p81 sig_type=std_logic lab=DATA[17]}
