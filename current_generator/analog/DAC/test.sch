v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 80 -30 80 -20 {lab=#net1}
C {sg13g2_pr/sg13_hv_rf_pmos.sym} 60 -60 0 0 {name=M1
l=0.72u
w=1.0u
ng=1
m=1
rfmode=1
model=sg13_hv_pmos
spiceprefix=X
}
